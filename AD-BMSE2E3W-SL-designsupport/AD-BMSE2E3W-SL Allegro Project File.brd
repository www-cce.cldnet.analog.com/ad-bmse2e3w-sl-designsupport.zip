# Allegro board AD-BMSE2E3W-SL Allegro Project File.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
UART_RX: length 37.9
  TOP w0.203: v1(170.82,93.04) 170.31,93.55 P12.8 ; v1(178.44,61.85) 178.56,61.72 R367.1
  L6_SIGNAL w0.203: v1(170.82,93.04) 170.61,92.84 170.61,81.15 173.2,78.56 173.2,76.23 178.23,71.2 178.23,62.05 v1(178.44,61.85)
UART_TX: length 42.8
  TOP w0.203: R368.1 179.24,60.45 v1(177.55,60.45)
  TOP w0.254: P12.6 171.58,93.65 v1(171.73,93.5)
  L6_SIGNAL w0.203: v1(177.55,60.45) 177.55,69.09 174.5,72.14 P14.6 172.77,72.39 171.78,73.38 171.78,75.01 170.05,76.73 170.05,93.45 170.46,93.85 171.37,93.85 v1(171.73,93.5)
UNNAMED_2_DIO3PV14_I258_C: length 159.1
  BOTTOM w0.381: D36.3 D41.3 D39.3 11.98,37.46 D35.3 12.03,46.51 D34.3 12.13,55.45 D40.3 12.13,75.77 D33.C 12.26,75.9 D38.3 D37.3 D25.3 D26.3 D27.3 D28.3 75.63,75.9 75.9,75.63 75.9,62.16 D29.3 74.02,60.17 D30.3 73.97,51.28 D31.3 D32.3
UNNAMED_2_DIO_I187_N: length 1.7
  TOP w0.508: D21.C R1.1
UNNAMED_3_ADBMS6830_I2_V: length 5.8
  TOP w0.254: U1.1 50.38,44.53 50.83,44.08 50.83,41.85 R58.2 50.58,41.61 C67.1
UNNAMED_3_ADBMS6830_I2_V_1: length 5.7
  TOP w0.254: R343.2 40.13,38.51 39.75,38.89 39.75,40.36 40.55,41.16 U1.66
UNNAMED_3_ADBMS6830_I2_VREF1: length 6
  TOP w0.254: U1.70 42.55,40.77 42.16,40.39 42.16,38.65 C65.1
UNNAMED_3_DIOLED_I56_N: length 7.8
  TOP w0.203: 49.99,32.81 49.99,33.1 50.29,33.4 50.29,33.5 v1(50.43,33.64) ; 49.99,32.81 Q1.4 ; 49.99,32.81 v1(50.05,32.88)
  TOP w0.254: Q1.2 DS1.C 41.3,28.84 C316.2
  vias: v1(46.81,28.63) v1(46.86,33.65) v1(46.86,32.03) v1(46.86,30.35) v1(47.19,27.86) v1(47.24,32.89) v1(47.24,31.27) v1(47.24,29.59) v1(48.01,33.65) v1(48.01,32.03) v1(48.01,30.35) v1(47.96,28.63) v1(48.51,32.89) v1(48.51,31.27) v1(48.51,29.59) v1(48.46,27.86) v1(49.42,33.64) v1(49.45,27.86) v1(50.32,27.86)
UNNAMED_3_FERRITE_I13_N1: length 3.1
  TOP w0.635: E1.1 42.32,27.18 43.45,28.31 Q1.3
UNNAMED_3_RES_I11_N2: length 1.5
  TOP w0.254: DS1.A R59.2
UNNAMED_3_RES_I14_N2: length 2.6
  TOP w0.635: Q1.1 43.5,32.91 42.62,33.78 R61.2
UNNAMED_4_CAP_I8_N1: length 29
  BOTTOM w0.254: P2.7 24.64,17.79 24.64,19.94 29.57,24.87 32.11,24.87 37.8,30.56 40.63,30.56 C85.1 41.57,32.89 R77.2 R69.2
UNNAMED_4_CAP_I10_N1: length 30.1
  BOTTOM w0.254: P2.5 25.61,17.61 38,30 44.01,30 C83.1 45.5,32.89 R67.2 R75.2
UNNAMED_4_CAP_I12_N1: length 40.1
  BOTTOM w0.254: P2.3 28.11,16.83 31.72,20.45 35.33,20.45 41.53,26.64 54.69,26.64 56.55,28.51 C81.1 56.55,33.15 R73.2 R65.2
UNNAMED_4_CAP_I15_N1: length 39.7
  BOTTOM w0.254: R71.2 R63.2 60.71,31.79 C79.1 60.74,31.43 54.13,24.82 40.97,24.82 35.84,19.68 34.04,19.68 P2.1
UNNAMED_4_FERRITE_I19_N2: length 25.3
  L3_SIGNAL w0.254: v1(57.91,34.92) 57.4,35.43 43.47,35.43 v1(42.67,34.63) 42.65,34.61 v1(39.05,34.61)
  BOTTOM w0.254: R73.1 57.87,34.89 v1(57.91,34.92) 57.95,34.89 R71.1 ; E2.2 v1(39.05,34.61) ; R77.1 v1(42.67,34.63) R75.1
UNNAMED_4_FERRITE_I40_N2: length 21.5
  TOP w0.254: 14.61,16.64 14.73,16.51 14.73,13.42 ; 14.61,16.64 18.67,16.64 19.01,16.29 E3.2 ; 14.61,16.64 8.05,16.64 7.87,16.46 7.87,13.42 ; R72.1 14.73,13.42 ; 14.73,13.42 R74.1 ; 7.87,13.42 R76.1 ; 7.87,13.42 R78.1
UNNAMED_5_CAP_I6_N1: length 2.9
  TOP w0.254: R83.2 26.2,37.46 C91.1 27.64,37.38 R85.2
UNNAMED_5_CAP_I18_N1: length 3.5
  TOP w0.203: 24.77,30.05 T1.15
  TOP w0.508: v1(24.77,32.38) 24.77,30.05
  BOTTOM w0.508: v1(24.77,32.38) C93.1
UNNAMED_5_CAP_I20_N1: length 3.1
  TOP w0.203: 31.11,30.05 T1.10
  TOP w0.508: v1(31.11,32.26) 31.11,30.05
  BOTTOM w0.508: C94.1 v1(31.11,32.26)
UNNAMED_5_CAP_I32_N1: length 2.9
  TOP w0.254: R84.2 34.63,37.46 C92.1 36.07,37.5 R86.2
UNNAMED_5_DIOZNRV3_I10_N2: length 9.7
  TOP w0.203: T1.16 23.5,30.05
  TOP w0.254: 23.5,30.05 23.5,32.38 24.13,33.02 24.13,35.01 D1.2 23.15,36.06 R83.1 R79.2
UNNAMED_5_DIOZNRV3_I28_N2: length 12.8
  TOP w0.203: 32.38,30.05 T1.9
  TOP w0.254: 32.38,30.05 32.38,33.25 32.74,33.6 33.86,33.6 36.28,36.03 D4.2 37.81,36.06 R86.1 R82.2
UNNAMED_5_DIOZNRV3_I30_N2: length 10.1
  TOP w0.203: T1.11 29.84,30.05
  TOP w0.254: R80.2 R84.1 31.5,37.43 D2.2 30.69,36.03 30.48,35.81 30.48,33.4 29.84,32.77 29.84,30.05
UNNAMED_5_RES_I2_N2: length 10.7
  TOP w0.203: T1.14 26.04,30.05
  TOP w0.254: 26.04,30.05 26.04,33.15 28.91,36.03 D3.2 29.46,37.43 R85.1 R81.2
UNNAMED_6_DIO3PV14_I197_C: length 157.7
  BOTTOM w0.381: D49.3 D48.3 D47.3 D46.3 156.39,62.88 156.39,73.01 D50.C 155.93,74.32 154.35,75.9 D45.3 D44.3 D43.3 D42.3 D53.3 D56.3 94.29,75.9 91.89,73.5 D57.3 91.89,55.5 D51.3 D54.3 D58.3 D55.3 D52.3
UNNAMED_6_DIO_I173_N: length 2
  TOP w0.762: 161.42,87.87 161.42,87.57 D24.C
  TOP w0.889: 161.42,87.87 R341.1
UNNAMED_7_ADBMS6830_I8_V: length 5.5
  TOP w0.254: U3.1 129.89,44.53 130.3,44.11 R143.2 130.26,41.61 C161.1
UNNAMED_7_ADBMS6830_I8_V_1: length 5.8
  TOP w0.254: U3.66 120.22,41.19 120.22,41.19 120.22,40.4 120.19,40.37 120.19,37.98 R344.2
UNNAMED_7_ADBMS6830_I8_VREF1: length 6.3
  TOP w0.254: U3.70 122.22,40.56 121.54,39.88 121.54,38.86 122.6,37.8 C159.1
UNNAMED_7_DIOLED_I14_N: length 14.8
  TOP w0.203: 129.11,30.61 129.51,31.01 129.51,33.4 129.31,33.6 v1(128.04,33.6)
  TOP w0.254: Q2.4 Q2.2 121.28,30.61 121.07,30.82 ; 121.07,30.82 C342.2 ; 121.07,30.82 DS2.C
  vias: v1(126.7,28.6) v1(126.7,27.48) v1(126.75,33.65) v1(126.75,32.64) v1(126.75,31.5) v1(126.75,29.97) v1(128.02,32.64) v1(128.02,31.5) v1(128.02,29.97) v1(127.97,28.6) v1(127.97,27.48) v1(129.41,33.65) v1(129.41,32.64) v1(129.41,31.52) v1(129.41,29.95) v1(129.36,28.57) v1(129.36,27.46)
UNNAMED_7_FERRITE_I18_N1: length 2.8
  TOP w0.635: E4.1 122.48,27.69 123.1,28.31 Q2.3
UNNAMED_7_RES_I13_N2: length 2.6
  TOP w0.635: R146.2 121.89,33.91 122.9,32.91 Q2.1
UNNAMED_8_CAP_I38_N1: length 41.1
  BOTTOM w0.254: R156.2 R148.2 140.38,31.79 C173.1 140.42,27.77 133.99,21.34 120.02,21.34 114.94,16.26 P5.1
UNNAMED_8_CAP_I40_N1: length 39.4
  BOTTOM w0.254: R150.2 R158.2 136.22,33.15 C175.1 136.27,31.7 136.27,28.57 129.92,22.22 118.75,22.22 114.48,17.96 109.65,17.96 108.5,16.8 P5.3
UNNAMED_8_CAP_I45_N1: length 39.3
  BOTTOM w0.254: P5.5 108.41,18.67 114.43,18.67 118.85,23.09 129.41,23.09 132.49,26.17 C177.1 132.49,33.15 R152.2 R160.2
UNNAMED_8_CAP_I47_N1: length 34.8
  BOTTOM w0.254: R154.2 R162.2 125.38,33.15 C179.1 125.38,25.76 124,24.38 119.25,24.38 114,19.13 106.37,19.13 P5.7
UNNAMED_8_FERRITE_I5_N1: length 5
  TOP w0.254: R338.2 R392.2 100.24,15.87 E6.1
UNNAMED_8_FERRITE_I5_N2: length 16.8
  TOP w0.254: E6.2 99.78,13.68 v1(99.75,13.65) ; R161.1 89.12,13.68 v1(89.09,13.65) 89.07,13.68 R163.1 ; R159.1 95.08,13.68 v1(95.89,14.48) 96.01,14.35 96.01,14.31 R157.1
  L3_SIGNAL w0.254: v1(89.09,13.65) 89.92,14.48 v1(95.89,14.48) 98.93,14.48 v1(99.75,13.65)
UNNAMED_8_FERRITE_I10_N2: length 24.6
  L3_SIGNAL w0.254: v1(122.86,34.11) 123.63,34.89 v1(129.58,34.89) 129.77,35.08 137.48,35.08 v1(137.67,34.89)
  BOTTOM w0.254: R160.1 v1(129.58,34.89) R162.1 ; R158.1 v1(137.67,34.89) R156.1 ; v1(122.86,34.11) 122.11,34.87 E5.2
UNNAMED_9_CAP_I9_N1: length 2.9
  TOP w0.254: R169.2 113.03,37.38 C186.1 114.47,37.34 R171.2
UNNAMED_9_CAP_I18_N1: length 4.3
  TOP w0.203: 111.67,30.69 T2.10
  TOP w0.508: v1(112.14,33.53) 112.14,32.64 111.67,32.17 111.67,30.69
  BOTTOM w0.508: v1(112.14,33.53) 112.14,33.06 C188.1
UNNAMED_9_CAP_I27_N1: length 3
  TOP w0.254: R168.2 R170.2
UNNAMED_9_CAP_I32_N1: length 3.9
  TOP w0.203: 105.32,30.69 T2.15
  TOP w0.508: v1(105.37,33.53) 105.37,30.74 105.32,30.69
  BOTTOM w0.508: C187.1 v1(105.37,33.53)
UNNAMED_9_DIOZNRV3_I11_N2: length 8.6
  TOP w0.203: T2.11 110.4,30.69
  TOP w0.254: R165.2 R169.1 111.25,37.3 D6.2 110.4,35.05 110.4,30.69
UNNAMED_9_DIOZNRV3_I29_N2: length 8.8
  TOP w0.203: 104.05,30.69 T2.16
  TOP w0.254: R164.2 R168.1 102.78,35.81 D5.2 104.05,34.46 104.05,30.69
UNNAMED_9_RES_I15_N1: length 10.1
  TOP w0.203: T2.9 112.94,30.69
  TOP w0.254: R167.2 R171.1 117.56,35.99 D8.2 117.47,35.69 112.94,31.16 112.94,30.69
UNNAMED_9_RES_I25_N2: length 9.3
  TOP w0.203: T2.14 106.59,30.69
  TOP w0.254: 106.59,30.69 106.59,33.4 D7.2 109.18,35.99 R170.1 R166.2
UNNAMED_10_ADBMS2950_I1_GPIO3: length 3.4
  TOP w0.203: U5.30 173.18,15.62 172.55,14.99 R330.1
UNNAMED_10_ADBMS2950_I1_GPIO4: length 4.3
  TOP w0.203: R331.1 172.43,13.54 173.25,14.36 173.25,14.92 173.5,15.18 173.97,15.18 174.03,15.12 U5.31
UNNAMED_10_ADBMS2950_I1_VBAT1: length 5.3
  TOP w0.203: U5.12 182.71,18.12 v1(183.64,19.05)
  BOTTOM w0.508: v1(183.64,19.05) 184.01,19.05 C192.1 185.08,20.12 R184.2
UNNAMED_10_ADBMS2950_I1_VBAT2: length 6.3
  TOP w0.254: v1(181.99,20.32) 181.19,19.52 U5.14
  BOTTOM w0.508: R185.2 183.59,22.85 C193.2 181.86,20.45 v1(181.99,20.32)
UNNAMED_10_ADBMS2950_I1_VREF1: length 2.7
  TOP w0.203: C196.1 181.38,10.07 180.81,10.64 180.81,10.64 180.29,11.16 180.29,11.17 180.19,11.26 U5.45
UNNAMED_10_ADBMS2950_I1_VREF2: length 2.2
  TOP w0.203: U5.43 179.19,10.2 C194.1
UNNAMED_10_ADLTC3639_I78_RUN: length 11.4
  TOP w0.254: R187.2 131.57,5.35 v1(131.57,6.1) ; v1(131.83,12.95) 133.35,12.95 133.59,12.71 U6.14
  BOTTOM w0.254: v1(131.57,6.1) 131.57,12.7 v1(131.83,12.95)
UNNAMED_10_ADLTC3639_I78_SS: length 11.4
  TOP w0.203: U6.10 v1(135.59,12.8)
  TOP w0.254: 135.59,5.74 v1(135.61,5.71) ; 135.59,5.74 U6.7 ; 135.59,5.74 135.59,4.88 C198.1
  L6_SIGNAL w0.203: v1(135.59,12.8) 136.27,12.12 136.27,6.38 v1(135.61,5.71)
UNNAMED_10_ADLTC3639_I78_SW: length 13.2
  TOP w0.508: 131.31,7.12 U6.1
  TOP w0.762: 131.31,7.12 130.17,8.26 L1.1
UNNAMED_10_CNTP1P_I140_N1: length 17.1
  BOTTOM w0.762: TP13.1 304.17,36.83 315.25,36.83 R375.N1
UNNAMED_10_RES_I48_N2: length 1.7
  TOP w0.508: R178.1 R177.2
UNNAMED_10_RES_I49_N2: length 1.7
  TOP w0.508: R179.1 R178.2
UNNAMED_10_RES_I125_N1: length 3.3
  TOP w0.203: R181.2 178.27,27.26 R183.1 178.11,27.41 RT2.2
UNNAMED_10_RES_I128_N1: length 3.3
  TOP w0.203: RT1.1 179.9,27.41 R172.1 179.87,27.3 R173.1
UNNAMED_11_CAP_I9_N1: length 2.9
  TOP w0.203: R194.2 171.92,24.13 C208.1 170.48,24.04 R196.2
UNNAMED_11_CAP_I18_N1: length 2.6
  TOP w0.254: T3.10 v1(160.15,26.8)
  BOTTOM w0.508: v1(160.15,26.8) 160.11,26.76 C210.1
UNNAMED_11_CAP_I26_N1: length 3.3
  TOP w0.254: R193.2 166.62,18.38 C207.1 166.54,16.65 R195.2
UNNAMED_11_CAP_I31_N1: length 3.7
  TOP w0.508: T3.15 166.5,27.18 v1(165.48,26.16)
  BOTTOM w0.508: v1(165.48,26.16) 166.2,26.16 C209.1
UNNAMED_11_DIOZNRV3_I11_N2: length 19.4
  TOP w0.203: v1(174.24,27.18) 175.01,26.42 175.01,25.95 D10.2 174.97,25.9 R194.1 R190.2
  TOP w0.254: T3.11 v1(161.42,26.92)
  L3_SIGNAL w0.203: v1(161.42,26.92) 173.99,26.92 v1(174.24,27.18)
UNNAMED_11_DIOZNRV3_I28_N2: length 11.6
  TOP w0.203: T3.16 167.77,27.43 166.62,26.29 R193.1
  TOP w0.254: R189.2 R193.1 165.35,21.42 D9.2
UNNAMED_11_RES_I15_N1: length 15.6
  TOP w0.203: R192.2 R196.1 168.57,24.25 D12.2
  TOP w0.254: T3.9 v1(158.88,26.8) ; v1(167.26,25.15) 168.02,25.91 D12.2
  L3_SIGNAL w0.254: v1(158.88,26.8) 160.53,25.15 v1(167.26,25.15)
UNNAMED_11_RES_I24_N2: length 18
  TOP w0.203: R191.2 R195.1 164.74,14.83 D11.2 163.83,15.71 163.83,26.16 165.23,27.56 T3.14
UNNAMED_12_ADLT8303_I103_RFB: length 1.9
  TOP w0.635: U9.3 168.77,40.87 R201.1
UNNAMED_12_ADLT8303_I103_SW: length 11.6
  TOP w0.635: U9.4 167.67,42.91 R201.2 169.24,43.04 169.24,47.88 168.78,48.34 D18.A 167.59,48.37 T4.1
UNNAMED_12_CAP_I34_N1: length 2.9
  TOP w0.203: T5.10 181.13,44.05
  TOP w0.508: v1(181.14,45.86) 181.14,44.06 181.13,44.05
  BOTTOM w0.508: C217.1 v1(181.14,45.86)
UNNAMED_12_CAP_I41_N1: length 2.9
  TOP w0.254: R207.2 183.41,48.93 C219.1 181.95,48.89 R203.2
UNNAMED_12_CAP_I60_N1: length 2.9
  TOP w0.203: 174.78,44.05 T5.15
  TOP w0.508: v1(174.78,45.8) 174.78,44.05
  BOTTOM w0.508: v1(174.78,45.8) 174.78,46.9 C216.1
UNNAMED_12_CAP_I62_N1: length 2.9
  TOP w0.254: R202.2 174.23,48.87 C218.1 175.67,48.88 R206.2
UNNAMED_12_DIOSCHOTTKY_I117_P: length 2.9
  TOP w0.508: T4.6 170.22,62.85 D19.A
UNNAMED_12_DIOSCHOTTKY_I133_N: length 5
  TOP w0.635: D17.C 167.61,45.53 D18.C
UNNAMED_12_DIOZNRV3_I36_N2: length 7.5
  TOP w0.203: 182.4,44.05 T5.9
  TOP w0.254: R209.1 185.12,48.96 R207.1 185.13,47.1 D16.2 182.4,44.37 182.4,44.05
UNNAMED_12_DIOZNRV3_I38_N2: length 6.7
  TOP w0.203: 179.86,44.05 T5.11
  TOP w0.254: R205.1 178.86,50.29 R203.1 178.86,48.89 D14.2 179.86,46.09 179.86,44.05
UNNAMED_12_DIOZNRV3_I58_N2: length 6.8
  TOP w0.203: 176.05,44.05 T5.14
  TOP w0.254: 176.05,44.05 176.05,45.74 D15.2 177.38,47.07 R206.1 177.38,50.29 R208.1
UNNAMED_12_DIOZNRV3_I59_N2: length 7.3
  TOP w0.203: 173.51,44.05 T5.16
  TOP w0.254: 173.51,44.05 173.51,44.67 D13.2 171.11,48.87 R202.1 171.11,50.29 R204.1
UNNAMED_13_ADBMS6822_I1_PHAPOL: length 6.5
  TOP w0.254: 191.95,45.69 192.06,45.58 U10.14
  TOP w0.508: R210.2 R211.1 191.57,46.08 191.95,45.69
UNNAMED_13_ADBMS6822_I1_RTO: length 5
  TOP w0.203: R216.1 190.61,45.08 U10.15
UNNAMED_13_ADBMS6822_I1_VDD: length 20.1
  TOP w0.254: U10.12 v1(193.17,46.58) 193.17,46.34 193.43,46.08 U10.13
  TOP w0.508: R398.2 192.01,52.93 E7.2 189.99,50.81 C226.1 C224.1 190.08,49.2 191.08,49.2 v1(191.29,49) ; R210.1 v1(187.35,47.6)
  L6_SIGNAL w0.508: v1(187.35,47.6) 188.75,49 v1(191.29,49) 191.39,48.89 191.39,47.39 192.2,46.58 v1(193.17,46.58)
UNNAMED_13_ADBMS6822_I1_XCVRMD: length 5.4
  TOP w0.203: U10.16 191.63,44.58 R214.1
UNNAMED_13_ADBMS6822_I36_MSTR2: length 23.5
  TOP w0.254: v1(200.39,43.27) 199.61,44.04 U10.25 ; U10.21 197.48,43.14 197.23,42.88 196.98,42.88 U10.20
  TOP w0.508: R212.1 197.87,38.68 197.36,38.18 192.91,38.18 192.41,38.68 E8.2 192.57,40.91 C227.1 C225.1 v1(196.34,41.88) 197.09,42.63 197.09,42.88
  L4_POWER w0.508: v1(196.34,41.88) 199.01,41.88 v1(200.39,43.27)
UNNAMED_13_ADBMS6822_I36_PHAPOL2: length 4.6
  TOP w0.203: U10.22 197.98,41.07 R212.2 R213.1
UNNAMED_13_ADBMS6822_I36_RTO2: length 4
  TOP w0.203: U10.23 198.48,43.39 R217.1
UNNAMED_13_ADBMS6822_I36_XCVRMD2: length 5.3
  TOP w0.203: R215.1 202.44,41.5 201.93,42.01 200.43,42.01 198.98,43.46 U10.24
UNNAMED_15_ADLTC7001_I1_BST: length 3.1
  TOP w0.254: C240.1 218.85,54.6 U12.9
UNNAMED_15_ADLTC7001_I1_TGDN: length 2.2
  TOP w0.254: 220.98,53.29 U12.6 U12.7
  TOP w0.508: 220.98,53.29 221.26,53.57 R227.2
UNNAMED_15_ADLTC7001_I1_TS: length 33.1
  TOP w0.254: U12.8 219.35,54.66 C240.2
  TOP w0.762: Q7.3 v1(229.24,55.04) ; C240.2 v1(220.58,57.46)
  L6_SIGNAL w0.762: v1(220.58,57.46) 223.62,57.46 226.03,55.04 v1(229.24,55.04)
  BOTTOM w0.254: R396.1 225.99,37.53 R377.2
  BOTTOM w0.762: v1(229.24,55.04) 229.84,54.44 D61.C 229.84,49.63 R379.2 227.18,47.02
UNNAMED_15_ADLTC7001_I21_BST: length 2.6
  TOP w0.254: U11.9 221.91,32.05 222.78,32.92 C234.1
UNNAMED_15_ADLTC7001_I21_TGDN: length 176.2
  TOP w0.254: v1(220.98,29.84) 220.78,30.05 U11.6 U11.7
  TOP w0.508: R383.2 291.68,34.5 v1(291.59,34.42) ; R222.2 v1(266.28,41.27) ; R385.2 v1(291.68,7.62) ; R221.2 v1(266.28,15.88)
  L3_SIGNAL w0.508: v1(220.98,29.84) 226.06,29.84 230.25,34.04 230.25,51.31 230.89,51.94 266.31,51.94 ; v1(291.68,7.62) 290.96,8.34 290.96,24.89 291.68,25.61 v1(291.68,26.16) 291.21,26.63 291.21,34.04 v1(291.59,34.42) 291.59,35.69 289.43,37.85 289.43,47.75 285.24,51.94 266.31,51.94 ; 266.31,51.94 266.31,41.31 v1(266.28,41.27) v1(266.28,34.29) v1(266.28,15.88)
  BOTTOM w0.508: v1(266.28,34.29) R226.2 ; v1(291.68,26.16) R384.2
UNNAMED_15_ADLTC7001_I38_BST: length 2.8
  TOP w0.254: U13.9 220.48,44.72 C247.1
UNNAMED_15_ADLTC7001_I38_TGDN: length 77.5
  TOP w0.254: v1(222.89,43.38) U13.6 U13.7
  TOP w0.508: R380.2 v1(254.85,91.19)
  TOP w0.762: R228.2 254.85,66.08 v1(254.89,66.04)
  L3_SIGNAL w0.508: v1(254.85,91.19) v1(254.85,83.69) 254.89,83.65 v1(254.89,66.04) 254.89,65.66 252.73,63.5 233.68,63.5 225.17,54.99 225.17,45.67 v1(222.89,43.38)
  BOTTOM w0.508: v1(254.85,83.69) R223.2
UNNAMED_15_ADLTC7001_I38_TS: length 7.6
  TOP w0.254: U13.8 220.98,44.12 221.23,44.37 224,44.37 224.4,43.98 R345.1
  TOP w0.508: R345.1 224.87,43.63 D74.C
UNNAMED_15_DIOTVS_I115_P: length 9.6
  TOP w0.203: Q12.1 288.28,8.88 v1(288.29,8.89)
  TOP w0.762: Q12.1 285.25,8.89 v1(288.29,8.89) R385.1
  BOTTOM w0.762: v1(288.29,8.89) 288.32,8.92 D70.A
UNNAMED_15_DIOTVS_I119_P: length 7.9
  BOTTOM w0.762: D69.A 289.98,24.95 R384.1 285.25,27.3 Q11.1
UNNAMED_15_DIOTVS_I121_P: length 12.3
  TOP w0.762: R383.1 v1(289.98,34.16) ; R383.1 285.25,35.56 Q10.1 289.97,35.55 R383.1
  BOTTOM w0.762: v1(289.98,34.16) D68.A
UNNAMED_15_DIOTVS_I124_P: length 10.1
  BOTTOM w0.762: R386.1 280.45,75.57 Q13.1 274.8,76.49 D71.A
UNNAMED_15_DIOTVS_I127_P: length 11.6
  TOP w0.762: R388.1 275.73,57.78 Q15.1 v1(278.76,57.78)
  BOTTOM w0.762: v1(278.76,57.78) 278.75,57.78 D73.A
UNNAMED_15_DIOTVS_I129_P: length 8.7
  TOP w0.762: v1(276.48,85.22) 275.72,84.46 Q14.1 280.45,83.18 R387.1
  BOTTOM w0.762: D72.A v1(276.48,85.22)
UNNAMED_15_RES_I5_N1: length 12.9
  TOP w0.762: Q7.1 224.15,54.03 R227.1 223.68,52.82 225.04,51.46 v1(226.09,51.46)
  BOTTOM w0.762: D61.A v1(226.09,51.46)
UNNAMED_15_RES_I19_N1: length 7.7
  BOTTOM w0.762: Q3.1 259.85,33.02 R226.1 264.58,31.3 D59.A
UNNAMED_15_RES_I36_N1: length 14.2
  TOP w0.762: R228.1 253.14,67.3 v1(251.59,67.3) Q5.1
  BOTTOM w0.762: D63.A 251.58,67.31 v1(251.59,67.3) 246.87,67.3 D63.A
UNNAMED_15_RES_I77_N1: length 6.6
  TOP w0.762: R221.1 263.03,14.6 v1(263.03,14.6) Q4.1
  BOTTOM w0.762: D60.A 263.62,14.6 v1(263.03,14.6)
UNNAMED_15_RES_I81_N1: length 13.1
  TOP w0.762: v1(251.58,85.1) 251.57,85.09 D64.A
  BOTTOM w0.762: 251.57,85.09 248.42,85.09 Q8.1 v1(251.58,85.1) ; 251.57,85.09 251.59,85.09 ; 251.57,85.09 v1(251.58,85.1) ; R223.1 251.59,85.09 ; 251.59,85.09 v1(251.58,85.1)
UNNAMED_15_RES_I83_N1: length 10.9
  TOP w0.762: Q9.1 253.14,92.32 R380.1 v1(251.71,92.33)
  BOTTOM w0.762: D65.A v1(251.71,92.33)
UNNAMED_15_RES_I90_N1: length 7.6
  TOP w0.762: v1(264.54,38.61) 264.54,39.97 R222.1 259.85,40 Q6.1
  BOTTOM w0.762: D62.A v1(264.54,38.61)
UNNAMED_15_RES_I128_N2: length 26.7
  TOP w0.508: R387.2 v1(282.15,81.88) ; R388.2 v1(282.15,58.89)
  L3_SIGNAL w0.508: v1(282.15,81.88) v1(282.15,74.29) v1(282.15,58.89)
  BOTTOM w0.508: v1(282.15,74.29) R386.2
UNNAMED_16_ADMAX20337_I52_COM: length 11
  TOP w0.254: 184.75,80.49 184.72,80.53 U15.2 ; 184.75,80.49 184.75,81.54 ; 184.75,80.49 184.75,80.21 184.57,80.03 U15.1 ; 184.75,81.54 v1(184.73,81.56) 184.7,81.53 U15.4 ; 184.75,81.54 184.77,81.52 C249.1 ; v1(183.77,85.83) 184.18,85.41 U14.1
  L6_SIGNAL w0.254: v1(183.77,85.83) 183.77,82.52 v1(184.73,81.56)
UNNAMED_16_ADMAX25301A_I5_BYP: length 8.2
  TOP w0.203: C250.1 v1(179.74,85.75) ; U15.8 180.09,81.03 v1(179.76,81.36)
  L6_SIGNAL w0.203: v1(179.74,85.75) 180.59,84.89 180.59,82.19 v1(179.76,81.36)
UNNAMED_16_ADMAX25301A_I5_OUT1: length 13.6
  TOP w0.203: C251.1 180.83,80.54 U15.9 ; C250.2 179.52,82.45 180.45,81.53 U15.7
  TOP w0.254: U15.9 U15.10
  TOP w0.508: C250.2 178.73,81.6 C251.1 178.78,80.49 R231.2 179.44,78.31 R381.1 R382.1
UNNAMED_16_ADP151V2_I3_VOUT:
  vias: v1(171.6,77.19) v1(171.6,76.58) v1(172.24,77.19) v1(172.24,76.58)
UNNAMED_16_ADP151V2_I4_VOUT:
  vias: v1(168.73,87.15) v1(168.73,86.54)
UNNAMED_16_CN2P_I55_N1: length 35
  TOP w0.508: R381.2 v1(183.46,78.31)
  L6_SIGNAL w0.508: P15.1 205.26,95.73 201.55,92.02 192,92.02 190.17,90.2 190.17,85.01 v1(183.46,78.31)
UNNAMED_16_CN2P_I57_N1: length 3.4
  TOP w0.508: P16.1 177.08,76.67 R231.1
UNNAMED_16_CN2P_I59_N1: length 8.1
  TOP w0.254: P19.1 166.16,93.79 R232.1
UNNAMED_16_DIOLED_I40_P: length 1.6
  TOP w0.508: R347.1 DS4.A
UNNAMED_16_DIOLED_I44_P: length 1.8
  TOP w0.508: R348.1 DS5.A
UNNAMED_16_DIOLED_I47_P: length 1.6
  TOP w0.508: R349.1 DS6.A
UNNAMED_16_DIOLED_I51_P: length 1.6
  TOP w0.508: R346.1 DS3.A
UNNAMED_16_RES_I36_N1: length 4.5
  TOP w0.254: U14.2 183.41,84.91
  TOP w0.381: 183.41,84.91 183.09,85.23 R230.1 R229.1
UNNAMED_17_RES_I1_N2: length 1.4
  BOTTOM w0.203: R235.2 R236.1
UNNAMED_17_RES_I3_N2: length 1.4
  BOTTOM w0.203: R237.1 R236.2
UNNAMED_17_RES_I4_N2: length 1.4
  BOTTOM w0.203: R237.2 R238.1
UNNAMED_17_RES_I6_N2: length 3
  BOTTOM w0.203: R233.2 205.89,24.93 R240.1 R239.2
UNNAMED_17_RES_I10_N1: length 3.1
  BOTTOM w0.203: R247.1 205.92,20.41 R238.2 R239.1
UNNAMED_17_RES_I14_N2: length 1.4
  BOTTOM w0.203: R241.2 R242.1
UNNAMED_17_RES_I15_N2: length 1.4
  BOTTOM w0.203: R242.2 R243.1
UNNAMED_17_RES_I16_N2: length 1.4
  BOTTOM w0.203: R244.1 R243.2
UNNAMED_17_RES_I17_N2: length 3
  BOTTOM w0.203: R248.1 157.22,17.68 R244.2 R245.1
UNNAMED_17_RES_I18_N2: length 3.1
  BOTTOM w0.203: R234.2 155.72,22.26 R246.1 R245.2
UNNAMED_17_RES_I24_N1: length 1.4
  BOTTOM w0.203: R251.2 R252.1
UNNAMED_17_RES_I24_N2: length 1.4
  BOTTOM w0.203: R252.2 R253.1
UNNAMED_17_RES_I25_N2: length 1.4
  BOTTOM w0.203: R254.1 R253.2
UNNAMED_17_RES_I27_N2: length 3
  BOTTOM w0.203: R263.1 203.96,20.34 R254.2 R255.1
UNNAMED_17_RES_I28_N2: length 3
  BOTTOM w0.203: R255.2 R256.1 202.46,24.93 R249.2
UNNAMED_17_RES_I37_N2: length 1.4
  BOTTOM w0.203: R258.1 R257.2
UNNAMED_17_RES_I38_N2: length 1.4
  BOTTOM w0.203: R258.2 R259.1
UNNAMED_17_RES_I39_N2: length 1.4
  BOTTOM w0.203: R260.1 R259.2
UNNAMED_17_RES_I40_N1: length 3
  BOTTOM w0.203: R261.1 R260.2 152.41,17.69 R264.1
UNNAMED_17_RES_I42_N2: length 3
  BOTTOM w0.203: R250.2 152.42,22.26 R262.1 R261.2
UNNAMED_17_RES_I46_N2: length 1.4
  BOTTOM w0.203: R283.2 R284.1
UNNAMED_17_RES_I47_N2: length 1.4
  BOTTOM w0.203: R284.2 R285.1
UNNAMED_17_RES_I48_N2: length 1.4
  BOTTOM w0.203: R267.2 R268.1
UNNAMED_17_RES_I49_N2: length 1.4
  BOTTOM w0.203: R268.2 R269.1
UNNAMED_17_RES_I50_N1: length 3
  BOTTOM w0.203: R287.1 R286.2 197.22,20.34 R295.1
UNNAMED_17_RES_I53_N2: length 1.4
  BOTTOM w0.203: R286.1 R285.2
UNNAMED_17_RES_I55_N2: length 3
  BOTTOM w0.203: R287.2 R288.1 195.73,24.93 R281.2
UNNAMED_17_RES_I59_N2: length 1.4
  BOTTOM w0.203: R290.1 R289.2
UNNAMED_17_RES_I60_N2: length 1.4
  BOTTOM w0.203: R291.1 R290.2
UNNAMED_17_RES_I61_N2: length 1.4
  BOTTOM w0.203: R292.1 R291.2
UNNAMED_17_RES_I64_N1: length 3
  BOTTOM w0.203: R293.1 R292.2 147.06,17.55 R296.1
UNNAMED_17_RES_I68_N2: length 3
  BOTTOM w0.203: R293.2 R294.1 145.56,22.14 R282.2
UNNAMED_17_RES_I74_N2: length 1.4
  BOTTOM w0.203: R270.1 R269.2
UNNAMED_17_RES_I75_N2: length 3
  BOTTOM w0.203: R271.1 R270.2 200.65,20.34 R279.1
UNNAMED_17_RES_I77_N2: length 3
  BOTTOM w0.203: R271.2 R272.1 199.15,24.93 R265.2
UNNAMED_17_RES_I81_N2: length 1.4
  BOTTOM w0.203: R273.2 R274.1
UNNAMED_17_RES_I82_N2: length 1.4
  BOTTOM w0.203: R274.2 R275.1
UNNAMED_17_RES_I83_N2: length 1.4
  BOTTOM w0.203: R275.2 R276.1
UNNAMED_17_RES_I84_N1: length 3
  BOTTOM w0.203: R280.1 150.49,17.55 R276.2 R277.1
UNNAMED_17_RES_I86_N2: length 3
  BOTTOM w0.203: R266.2 148.99,22.14 R278.1 R277.2
UNNAMED_17_RES_I90_N2: length 1.4
  BOTTOM w0.203: R299.2 R300.1
UNNAMED_17_RES_I91_N2: length 1.4
  BOTTOM w0.203: R301.1 R300.2
UNNAMED_17_RES_I92_N2: length 1.4
  BOTTOM w0.203: R301.2 R302.1
UNNAMED_17_RES_I93_N2: length 3
  BOTTOM w0.203: R303.1 R302.2 193.92,20.34 R311.1
UNNAMED_17_RES_I100_N2: length 3
  BOTTOM w0.203: R297.2 192.42,24.93 R304.1 R303.2
UNNAMED_17_RES_I101_N2: length 1.4
  BOTTOM w0.203: R306.1 R305.2
UNNAMED_17_RES_I102_N2: length 1.4
  BOTTOM w0.203: R307.1 R306.2
UNNAMED_17_RES_I103_N2: length 1.4
  BOTTOM w0.203: R308.1 R307.2
UNNAMED_17_RES_I104_N1: length 3
  BOTTOM w0.203: R309.1 R308.2 143.76,17.55 R312.1
UNNAMED_17_RES_I106_N2: length 3
  BOTTOM w0.203: R309.2 R310.1 142.26,22.14 R298.2
UNNAMED_18_ADLTC2875_I77_CANH: length 8.1
  TOP w0.203: U19.7 201.27,89.89 200.77,90.39 R319.2 200.77,94.23 P10.2
UNNAMED_18_ADLTC2875_I77_CANL: length 7.4
  TOP w0.203: U19.6 201.77,89.26 R319.1 202.41,91.3 202.41,96.09 P10.1
UNNAMED_18_ADLTC2875_I77_RS: length 2.5
  TOP w0.203: R313.2 198.5,89.25 U19.8
UNNAMED_18_ADLTC2875_I77_TXD: length 1.9
  TOP w0.203: R314.1 200.38,85.32 200.77,85.71 U19.1
UNNAMED_18_ADMAX32690V2_I1_ANT: length 6.7
  TOP w0.203: U22.53 186.81,70.62 185.93,71.5 185.34,71.5 183.79,73.05 C285.2
UNNAMED_18_ADMAX32690V2_I1_BLELDOIN: length 48.5
  TOP w0.203: v1(187.22,72.57) 188.95,72.57 189.22,72.29 U22.50
  L6_SIGNAL w0.508: v1(187.22,72.57) 187.22,74.7 190.27,77.75 192.46,77.75 193.29,78.59 193.29,85.85 194.49,87.05 194.49,89.53 195.76,90.81 201.6,90.81 204.85,94.06 209.17,94.06 210.74,95.63 P22.1
  BOTTOM w0.203: v1(187.22,72.57) 184.67,72.57 C275.2 184.21,75.4 C280.2
UNNAMED_18_ADMAX32690V2_I1_HYPCLKN: length 7.2
  TOP w0.203: U22.28 199.98,68.62 R374.2
UNNAMED_18_ADMAX32690V2_I1_HYPCLKP: length 8.3
  TOP w0.203: U22.29 199.32,69.02 200.66,70.36 200.66,71.32 201.73,72.39 R373.2
UNNAMED_18_ADMAX32690V2_I1_P0: length 7
  TOP w0.203: R332.2 196.98,59.94 194.02,62.9 U22.14
UNNAMED_18_ADMAX32690V2_I1_P0_1: length 6.5
  TOP w0.203: R352.2 195.45,60.83 193.62,62.66 U22.13
UNNAMED_18_ADMAX32690V2_I1_P0_2: length 6.4
  TOP w0.203: U22.10 192.42,61.19 193.93,59.69 R351.2
UNNAMED_18_ADMAX32690V2_I1_P0_3: length 5.9
  TOP w0.203: U22.9 192.02,58.51 R350.2
UNNAMED_18_ADMAX32690V2_I1_P1: length 10.6
  TOP w0.203: R364.2 200.86,75.44 199.26,73.84 199.26,70.49 198.6,69.82 U22.31
UNNAMED_18_ADMAX32690V2_I1_P1_1: length 9.9
  TOP w0.203: R363.2 200.41,73.91 200.03,73.53 200.03,70.61 198.83,69.42 U22.30
UNNAMED_18_ADMAX32690V2_I1_P1_2: length 6.3
  TOP w0.203: U22.26 R362.2
UNNAMED_18_ADMAX32690V2_I1_P1_3: length 6.8
  TOP w0.203: U22.27 200.3,68.22 201.42,69.34 R361.2
UNNAMED_18_ADMAX32690V2_I1_P1_4: length 6.8
  TOP w0.203: U22.25 200.55,67.42 201.68,66.29 R360.2
UNNAMED_18_ADMAX32690V2_I1_P1_5: length 7.2
  TOP w0.203: R359.2 199.98,67.02 U22.24
UNNAMED_18_ADMAX32690V2_I1_P1_6: length 7.4
  TOP w0.203: U22.21 197.07,65.82 197.74,65.15 199.31,65.15 201.22,63.25 R358.2
UNNAMED_18_ADMAX32690V2_I1_P1_7: length 7.8
  TOP w0.203: U22.20 196.84,65.42 198.37,63.88 198.81,63.88 200.96,61.72 R357.2
UNNAMED_18_ADMAX32690V2_I1_P1_8: length 7.9
  TOP w0.203: R356.2 194.82,63.33 194.82,63.91 U22.16
UNNAMED_18_ADMAX32690V2_I1_P1_9: length 7.5
  TOP w0.203: R355.2 198.5,59.06 194.42,63.13 U22.15
UNNAMED_18_ADMAX32690V2_I1_P1_10: length 8.3
  TOP w0.203: U22.18 195.92,64.3 197.23,62.99 197.87,62.99 200.66,60.2 R354.2
UNNAMED_18_ADMAX32690V2_I1_P1_11: length 8.9
  TOP w0.203: U22.17 195.22,63.6 199.64,59.18 200.49,59.18 R353.2
UNNAMED_18_ADMAX32690V2_I1_P2: length 6.7
  TOP w0.203: R334.2 187.83,60.71 190.02,62.9 U22.4
UNNAMED_18_ADMAX32690V2_I1_P2_1: length 6.2
  TOP w0.203: R333.2 189.36,61.59 190.42,62.66 U22.5
UNNAMED_18_ADMAX32690V2_I1_P2_2: length 7.6
  TOP w0.203: R336.2 186.31,60.58 187.33,61.59 188.09,61.59 189.62,63.13 U22.3
UNNAMED_18_ADMAX32690V2_I1_P2_3: length 9.7
  TOP w0.203: R335.2 181.74,58.67 186.56,63.5 187.58,63.5 188.12,64.04 U22.68
UNNAMED_18_ADMAX32690V2_I1_P2_4: length 6.5
  TOP w0.203: U22.6 190.82,62.43 189.99,61.59 189.99,59.02 R370.2
UNNAMED_18_ADMAX32690V2_I1_P2_5: length 8.2
  TOP w0.203: R369.2 182.25,63.25 183.52,64.52 184.5,64.52 185.39,65.4 185.8,65.4 186.61,66.22 U22.64
UNNAMED_18_ADMAX32690V2_I1_P2_6: length 9.4
  TOP w0.203: R368.2 182.12,60.2 185.8,63.88 187.12,63.88 187.33,64.08 187.33,64.81 187.53,65.02 U22.67
UNNAMED_18_ADMAX32690V2_I1_P2_7: length 8.8
  TOP w0.203: R367.2 182.75,61.72 185.32,64.29 186.59,64.29 186.87,64.57 186.87,65.07 187.21,65.42 U22.66
UNNAMED_18_ADMAX32690V2_I1_P2_8: length 8.1
  TOP w0.203: R366.2 184.79,59.82 187.45,62.48 188.34,62.48 189.22,63.37 U22.2
UNNAMED_18_ADMAX32690V2_I1_P2_9: length 8.8
  TOP w0.203: U22.1 188.82,63.6 188.21,62.99 187.07,62.99 183.26,59.18 R365.2
UNNAMED_18_ADMAX32690V2_I1_P3: length 4
  TOP w0.203: R371.2 193.78,75.26 192.82,74.31 U22.41
UNNAMED_18_ADMAX32690V2_I1_P3_1: length 5.9
  TOP w0.203: U22.39 193.62,73.22 193.93,73.53 194.23,73.53 195.2,74.5 196.6,74.5 196.85,74.75 R220.2
UNNAMED_18_ADMAX32690V2_I1_P4: length 8.1
  TOP w0.203: U22.60 185.29,67.82 182.37,64.9 R372.2
UNNAMED_18_ADMAX32690V2_I1_VDDABB: length 18.2
  TOP w0.203: U22.49 189.62,72.5 188.98,73.15 187.58,73.15 186.35,74.38 C273.1 185.32,74.36 ; U22.56 185.09,69.42 v1(184.79,69.72)
  TOP w0.508: v1(184.79,69.72) 183.64,70.87 C271.1 ; v1(185.73,73.23) 185.32,73.63 185.32,74.36
  L6_SIGNAL w0.508: v1(185.73,73.23) 184.4,71.91 184.4,70.1 v1(184.79,69.72)
UNNAMED_18_ADMAX32690V2_I1_VDDARF: length 13.8
  TOP w0.203: U22.55 185.71,69.82 v1(185.17,70.36) 183.13,72.39 C269.1 C270.1 ; v1(187.71,71.88) 187.87,71.72 U22.51
  L3_SIGNAL w0.203: v1(185.17,70.36) 185.34,70.18 186.82,70.18 187.71,71.07 v1(187.71,71.88)
UNNAMED_18_ADMAX32690V2_I1_VDDB: length 36.8
  TOP w0.203: v1(196.22,71.91) 196.03,71.72 U22.35
  L6_SIGNAL w0.508: v1(196.22,71.91) 196.67,72.36 197.23,72.36 197.74,72.87 197.74,89.43 198.25,89.94 202.11,89.94 205.36,93.19 209.98,93.19 P21.1
  BOTTOM w0.508: v1(196.22,71.91) 196.7,72.39 C278.1
UNNAMED_18_ADMAX32690V2_I1_VREF: length 12.3
  TOP w0.203: R320.1 193.26,80.52 C286.1 192.93,79.12 P23.1 191.03,78.92 191.03,75.51 192.02,74.52 U22.43
UNNAMED_18_ADMAX32690V2_I1_VREG1: length 4.1
  TOP w0.203: U22.46 190.82,73.34 v1(190.12,74.04)
  BOTTOM w0.508: C274.2 189.96,74.04 v1(190.12,74.04)
UNNAMED_18_ADMAX32690V2_I1_VUSB0P9: length 7
  TOP w0.203: U22.38 194.02,72.74 195.38,74.09 198.2,74.09 198.4,74.29 C272.1
UNNAMED_18_CAP_I64_N1: length 11.6
  TOP w0.203: R324.2 196.29,87.98 C291.1 196.52,86.44 197.13,85.83 197.13,82.47 196.72,82.07 194.96,82.07 C289.1
  TOP w0.254: C289.1 192.76,84.27 U20.1
UNNAMED_18_CAP_I165_N2: length 7.1
  TOP w0.254: C289.2 191.31,82.14 P23.2 190.83,83.98 U20.6 188.93,84.27 R322.1
UNNAMED_18_CN5P6SHLD_I111_N1: length 3.2
  TOP w0.381: P11.1 185.7,95.61 186.08,95.22 186.63,95.22 L2.2
UNNAMED_18_CN5P6SHLD_I111_N11: length 10.6
  TOP w1.143: L3.2 180.81,96.47 P11.SH6
  TOP w1.524: P11.SH5 P11.SH4 P11.SH3 P11.SH2
UNNAMED_18_ICMAX6071_I114_GNDS: length 2.2
  TOP w0.254: R323.2 193.33,85.22 U20.2
UNNAMED_18_ICMAX6071_I114_OUTS: length 2
  TOP w0.254: U20.5 189.52,85.22 R322.2
UNNAMED_18_NCTESTPAD_I160_N1: length 20.7
  TOP w0.203: R219.1 196.16,77.86 v1(196.16,77.9)
  L3_SIGNAL w0.203: v1(196.16,77.9) 197.43,76.63 205.26,76.63 206.73,75.16 209.68,75.16 212.17,72.67 TP14.1
UNNAMED_18_RES_I101_N2: length 6
  TOP w0.203: R317.2 R318.2 172.82,89.41 R316.2 R315.2
V_SENSE1: length 4.5
  BOTTOM w0.203: P7.1 203.2,6.61 R235.1
V_SENSE2: length 4.2
  BOTTOM w0.203: R251.1 200.66,7.49 P7.3
V_SENSE3: length 3.8
  BOTTOM w0.203: R267.1 198.12,8.26 P7.5
V_SENSE4: length 3.5
  BOTTOM w0.203: P7.7 195.58,9.15 R283.1
V_SENSE5: length 3.7
  BOTTOM w0.203: R299.1 193.04,8.61 P7.9
V_SENSE6: length 23.1
  BOTTOM w0.254: R241.1 156.69,7.6 156.69,8.04 159.14,10.49 170.36,10.49 174.82,6.02 P8.1
V_SENSE7: length 23.7
  BOTTOM w0.254: R257.1 153.11,5.87 158.57,5.87 162.74,10.03 168.06,10.03 P8.3
V_SENSE8: length 24.6
  BOTTOM w0.254: P8.5 166.03,9.52 162.94,9.52 158.72,5.31 150.39,5.31 149.24,6.47 R273.1
V_SENSE9: length 23.8
  BOTTOM w0.254: R289.1 147.2,4.8 161.52,4.8 163.7,6.98 166.12,6.98 167.2,5.9 P8.7
V_SENSE10: length 25.9
  BOTTOM w0.203: R305.1 146.74,1.96 160.81,1.96 P8.9

## Copper pours and planes (outline as drawn)
1V1_VCORE on TOP: 206.12,56.11 206.12,54.38 204.09,54.38 203.63,54.84 203.63,56.06 203.68,56.11
1V1_VCORE on L5_POWER: 190.07,75.67 190.07,76.63 189.26,77.44 181.48,77.44 181.48,70.59 178.59,67.69 165.99,67.69 165.13,68.55 165.13,73.02 164.26,73.89 161.26,73.89 161.16,73.79 161.16,65.02 161.43,64.76 172.09,64.76 182.11,54.74 205.11,54.74 205.11,57.18 184.89,57.18 183.01,59.06 183.01,68.99 185.9,71.88 185.9,74.85 186.72,75.67
1V2_VBLE on TOP: 206.12,51.99 204.9,51.99 204.5,52.4 204.5,53.72 204.6,53.82 205,53.82 205.16,53.67 206.12,53.67
1V2_VBLE on TOP: 168.12,80.42 168.17,80.37 168.86,80.37 169.01,80.52 169.01,81.18 169.16,81.33 172.39,81.33 172.49,81.43 172.49,82.47 168.12,82.47
1V2_VBLE on L5_POWER: outline of 201 points within 165.61,51.54 211.91,99.44
1V8_VDD on TOP: 206.12,58.24 206.12,56.82 204.8,56.82 204.34,57.28 202.92,57.28 202.72,57.48 202.72,57.99 202.97,58.24
1V8_VDD on L5_POWER: 168.83,91.11 172.44,91.11 174.88,88.67 175.01,88.67 175.62,88.06 188.39,88.06 188.39,79.02 190.78,76.63 190.78,75.36 190.63,75.21 188.39,75.21 188.39,73.08 188.49,72.97 201.75,72.97 202.41,72.31 202.41,57.43 202.51,57.33 206.22,57.33 206.22,75.81 206.22,75.81 206.22,76.23 206.17,76.28 205.75,76.28 205.75,76.28 204.8,76.28 194.18,76.28 193.01,77.44 193.01,90.75 177.98,90.75 176.1,92.63 168.78,92.63 168.78,91.16
3V3_LDO on L4_POWER: 192.81,89.59 192.81,98.53 194.03,99.75 208.25,99.75 208.36,99.64 208.36,94.06 204.75,94.06 203.53,92.84 203.53,89.18 199.87,89.18 197.94,87.25 193.8,87.25 192.96,86.41 192.96,74.85 191.74,74.85 189.51,77.09 189.51,86.28
3V3_VDD on TOP: 190.37,41.63 187.07,41.63 186.94,41.5 186.94,39.98 187.07,39.85 190.37,39.85
3V3_VDD on TOP: 201.65,86.74 201.65,85.37 201.88,85.14 201.88,83.87 204.51,83.87 204.54,83.85 204.8,83.85 204.8,84.99 204.67,85.12 202.39,85.12 201.9,85.6 201.9,86.74 201.88,86.77 201.68,86.77
3V3_VDD on TOP: 167.03,80.04 167.11,79.96 167.89,79.96 167.92,79.98 167.92,80.9 167.87,80.95 167.87,82.47 164.97,82.47 164.97,81.33 166.85,81.33 167.03,81.15
3V3_VDD on TOP: 205.16,60.93 206.12,60.93 206.12,58.65 206.07,58.6 204.95,58.6 204.8,58.45 204.09,58.45 204.04,58.5 204.04,58.75 203.78,58.75 203.78,59.41 204.65,59.41 205.16,59.92
3V3_VDD on TOP: 167.03,84.99 167.11,84.91 167.89,84.91 167.92,84.94 167.92,85.85 167.87,85.9 167.87,87.43 164.97,87.43 164.97,86.28 166.85,86.28 167.03,86.11
3V3_VDD on TOP: 167.03,74.96 167.11,74.88 167.89,74.88 167.92,74.9 167.92,75.82 167.87,75.87 167.87,77.39 164.97,77.39 164.97,76.25 166.85,76.25 167.03,76.07
3V3_VDD on TOP: 203.43,48.64 203.43,47.37 205.36,47.37 205.87,46.86 205.87,45.9 206.48,45.9 206.48,47.57 206.78,47.88 206.78,49.5 205.46,49.5 204.6,48.64
3V3_VDD on TOP: 190.02,86.46 190.02,85.85 193.73,85.85 193.73,85.37 194.01,85.09 195,85.09 195.12,85.22 195.12,86.92 193.73,86.92 193.27,86.46
3V3_VDD on L4_POWER: 193.78,82.32 203.12,82.32 203.43,82.02 203.43,55.96 202.51,55.04 177.17,55.04 176.2,56.01 176.2,74.45 176.5,74.75 183.08,74.75 183.09,74.76 183.72,74.76 183.77,74.8 183.77,79.38 183.52,79.63 176.66,79.63 176.2,80.09 176.2,88.16 174.32,90.04 166.19,90.04 166.19,63.37 172.09,63.37 172.69,62.76 172.69,52.4 173.91,51.18 187.48,51.18 188.04,50.62 188.04,42.82 186.94,41.73 186.94,39.73 187.07,39.6 190.98,39.6 190.98,47.22 192.51,48.74 200.89,48.74 200.94,48.69 200.94,46.76 202.67,45.03 211.05,45.03 211.46,45.44 211.46,51.28 211.3,51.43 206.93,51.43 205.92,52.45 205.92,81.31 206.93,82.32 212.67,82.32 212.67,90.96 204.8,90.96 204.8,86.89 204.29,86.39 193.78,86.39
GND1 on TOP (solid shape): outline of 95 points within 27.98,48.25 31.98,53.01
GND1 on TOP: 0.64,0.63 83.06,0.63 83.06,100.96 0.64,100.96 ; 11 cut-outs
GND1 on BOTTOM, L2_GND, L3_SIGNAL, L5_POWER, L6_SIGNAL, L7_GND: 0.64,0.63 83.06,0.63 83.06,100.96 0.64,100.96
GND1 on L4_POWER: 0.64,0.63 83.06,0.63 83.06,100.96 0.64,100.96 ; 1 cut-out
GND2 on TOP (solid shape): 92.71,11.58 92.77,11.44 92.91,11.38 93.07,11.38 93.07,11.24 92.9,11.24 92.75,11.18 92.69,11.04 92.69,10.05 92.75,9.9 92.9,9.84 93.6,9.84 94.02,9.42 94.04,9.31 93.95,9.25 91.83,9.25 90.74,10.34 90.74,11.04 90.68,11.18 90.53,11.24 90.43,11.24 90.43,11.38 90.6,11.38 90.74,11.44 90.8,11.58 90.8,11.65 90.93,11.65 90.93,11.58 90.99,11.44 91.13,11.38 92.12,11.38 92.27,11.44 92.33,11.58 92.33,11.98 92.59,12.24 92.71,12.25
GND2 on L5_POWER (solid shape): outline of 295 points within 175.03,26.77 217.07,33.04
GND2 on TOP: 155.49,90.32 161.42,90.32 161.42,90.22 161.37,90.22 161.27,90.21 161.17,90.17 160.92,90.17 160.78,90.11 160.72,89.97 160.72,89.18 160.73,89.11 160.77,89.05 160.77,86.94 160.83,86.8 160.97,86.74 161.98,86.74 161.98,85.37 159.94,83.34 159.94,78.37 159.87,78.27 159.75,78.32 159.7,78.41 159.63,78.48 154.48,83.63 154.41,83.69 154.34,83.75 151.56,86.52 151.56,88.24 151.66,88.34 151.76,88.44 153.19,88.44 153.19,88.2 153.25,88.06 153.39,88 155.3,88 155.44,88.06 155.5,88.2 155.5,88.99 157.55,88.99 157.59,88.98 157.62,88.98 158.61,88.98 158.64,88.98 158.68,88.99 159.2,88.99 159.24,88.98 159.27,88.98 160.26,88.98 160.41,89.04 160.47,89.18 160.47,89.97 160.41,90.11 160.26,90.17 159.27,90.17 159.24,90.17 159.2,90.16 158.68,90.16 158.64,90.17 158.61,90.17 157.62,90.17 157.59,90.17 157.55,90.16 155.5,90.16 155.47,90.21 155.45,90.24
GND2 on TOP: 83.69,100.96 161.42,100.96 161.42,96.37 129.03,96.37 125.6,99.8 83.69,99.8
GND2 on TOP: 294.01,100.96 303.53,100.96 303.53,67.94 329.56,67.94 329.56,33.66 303.53,33.66 303.53,0.64 225.4,0.64 225.4,4.47 281.92,4.47 281.92,8.25 282.74,8.25 282.74,8.21 282.8,8.06 282.94,8.01 287.54,8.01 287.69,8.06 287.75,8.21 287.75,8.31 289.4,8.31 289.42,8.28 289.49,8.22 289.59,8.19 290.37,8.19 290.52,8.25 290.58,8.39 290.58,8.89 291.08,8.89 291.08,8.39 291.11,8.29 291.19,8.21 291.22,8.2 291.22,7.62 291.68,7.16 292.14,7.62 292.14,8.2 292.17,8.21 292.25,8.29 292.28,8.39 292.28,8.89 294.01,8.89 294.01,94.6 294.59,94.6 294.73,94.66 294.79,94.81 294.79,95.17 295,95.17 295,94.81 295.06,94.66 295.2,94.6 295.39,94.6 295.39,94.42 295.38,94.41 295.29,94.27 295.26,94.11 295.72,93.65 296.18,94.11 296.15,94.27 296.07,94.41 296.05,94.42 296.05,94.6 296.24,94.6 296.39,94.66 296.45,94.81 296.45,96.2 296.39,96.35 296.24,96.41 295.2,96.41 295.06,96.35 295,96.2 295,95.83 294.79,95.83 294.79,96.2 294.73,96.35 294.59,96.41 294.01,96.41
GND2 on TOP: outline of 145 points within 133.92,56.32 151.98,90.32
GND2 on TOP: 130.42,90.25 130.51,90.32 132.68,90.32 132.78,90.25 132.73,90.13 132.34,89.71 132.19,89.15 132.31,88.65 132.64,88.24 132.64,84.97 132.69,84.69 132.84,84.46 135.28,82.02 135.34,81.92 135.42,81.84 136.92,80.34 136.97,80.27 137.02,80.21 140.31,76.93 140.31,76.63 140.26,76.54 140.15,76.54 140.11,76.56 140.06,76.57 136.55,76.57 136.41,76.51 136.35,76.37 136.35,75.55 135.69,75.55 135.69,76.37 135.63,76.51 135.48,76.57 134.36,76.57 134.36,77.34 135.38,78.36 135.53,78.59 135.59,78.87 135.59,81.02 135.62,81.05 135.68,81.19 135.62,81.34 135.51,81.44 135.45,81.54 135.38,81.63 134.33,82.67 134.1,82.83 133.83,82.88 130.47,82.88 128.77,84.58 128.77,86.19 130.35,87.78 130.5,87.99 130.56,88.24 130.89,88.65 131,89.15 130.86,89.71 130.46,90.13
GND2 on TOP: 140.92,90.25 141.01,90.32 143.18,90.32 143.28,90.25 143.23,90.13 142.84,89.71 142.69,89.15 142.81,88.65 143.14,88.24 143.14,83.99 143.19,83.72 143.34,83.49 144.62,82.21 144.85,82.06 145.12,82 149.58,82 149.61,81.97 149.63,81.85 149.51,81.8 149.42,81.82 149.32,81.83 145.24,81.83 145.15,81.85 145.06,81.85 143.31,81.85 141.06,84.1 141.06,88.24 141.39,88.65 141.5,89.15 141.36,89.71 140.96,90.13
GND2 on TOP: 215.37,53.34 218,53.34 218,52.72 218.06,52.57 218.2,52.51 219.71,52.51 219.71,49.85 219.67,49.85 219.55,49.78 219.5,49.65 219.5,48.5 219.51,48.43 219.55,48.37 219.55,48.05 219.52,48.04 219.43,47.99 219.36,47.92 219.24,47.89 219.18,47.98 219.18,50.27 215.37,50.27
GND2 on TOP: 153.4,75.77 153.46,75.87 153.58,75.85 154.48,74.94 154.48,67.29 154.43,67.2 154.33,67.2 154.27,67.23 154.22,67.23 153.4,67.23 153.4,75.76
GND2 on TOP: 147.92,90.25 148.01,90.32 150.18,90.32 150.28,90.25 150.23,90.13 149.84,89.71 149.69,89.15 149.81,88.65 150.14,88.24 150.14,86.23 150.19,85.96 150.34,85.73 153.44,82.63 153.51,82.57 153.59,82.52 158.4,77.7 158.38,77.56 158.24,77.57 158.24,77.58 153.37,82.45 153.32,82.51 152.1,83.73 152.05,83.8 151.99,83.87 148.06,87.8 148.06,88.24 148.39,88.65 148.5,89.15 148.36,89.71 147.96,90.13
GND2 on TOP: 144.42,90.25 144.51,90.32 146.68,90.32 146.78,90.25 146.73,90.13 146.34,89.71 146.19,89.15 146.31,88.65 146.64,88.24 146.64,87.5 146.69,87.23 146.84,87 150.87,82.97 150.93,82.89 150.98,82.83 152.25,81.56 152.31,81.5 157.02,76.78 157.02,76.69 156.99,76.65 156.94,76.66 150.38,83.22 150.15,83.37 149.87,83.43 145.42,83.43 144.56,84.29 144.56,88.24 144.89,88.65 145,89.15 144.86,89.71 144.46,90.13
GND2 on TOP: outline of 1239 points within 83.69,0.64 240.05,95.78 ; 16 cut-outs
GND2 on TOP: 137.42,90.25 137.51,90.32 139.68,90.32 139.78,90.25 139.73,90.13 139.34,89.71 139.19,89.15 139.31,88.65 139.64,88.24 139.64,83.81 139.69,83.54 139.84,83.3 142.51,80.64 142.74,80.48 143.02,80.43 144.9,80.43 144.99,80.41 145.08,80.4 149.02,80.4 149.14,80.28 149.09,80.23 149.06,80.23 148.98,80.25 148.91,80.25 141.35,80.25 139.16,82.44 139.12,82.48 139.08,82.52 137.56,84.03 137.56,88.24 137.89,88.65 138,89.15 137.86,89.71 137.46,90.13
GND2 on BOTTOM: 83.69,100.96 303.53,100.96 303.53,67.94 329.56,67.94 329.56,33.66 303.53,33.66 303.53,0.64 83.69,0.64 ; 1 cut-out
GND2 on L2_GND: 83.69,100.96 303.53,100.96 303.53,67.94 329.56,67.94 329.56,33.66 303.53,33.66 303.53,0.64 83.69,0.64 ; 1 cut-out
GND2 on L3_SIGNAL: 83.69,100.96 303.53,100.96 303.53,67.94 329.56,67.94 329.56,33.66 303.53,33.66 303.53,0.64 83.69,0.64 ; 4 cut-outs
GND2 on L4_POWER: 83.69,100.96 303.53,100.96 303.53,67.94 329.56,67.94 329.56,33.66 303.53,33.66 303.53,0.64 83.69,0.64 ; 3 cut-outs
GND2 on L5_POWER: 83.69,100.96 303.53,100.96 303.53,67.94 329.56,67.94 329.56,33.66 303.53,33.66 303.53,0.64 83.69,0.64 ; 3 cut-outs
GND2 on L6_SIGNAL: 83.69,100.96 303.53,100.96 303.53,67.94 329.56,67.94 329.56,33.66 303.53,33.66 303.53,0.64 83.69,0.64 ; 6 cut-outs
GND2 on L7_GND: 215.37,100.96 303.53,100.96 303.53,67.94 329.56,67.94 329.56,33.66 303.53,33.66 303.53,0.64 83.69,0.64 83.69,100.96 161.42,100.96 161.42,92.68 161.98,92.13 161.98,85.37 159.94,83.34 159.94,52.91 159.99,52.86 169.65,52.86 169.65,43.87 170.87,42.65 170.87,36.3 170.92,36.25 205.66,36.25 205.66,37.87 211.4,37.87 211.4,44.98 215.37,44.98 215.37,53.62 215.43,53.71 215.55,53.68 215.71,53.56 215.9,53.52 216.36,53.97 215.9,54.43 215.71,54.39 215.55,54.27 215.43,54.24 215.37,54.33 215.37,66.95 215.43,67.05 215.55,67.02 215.71,66.9 215.9,66.85 216.36,67.31 215.9,67.77 215.71,67.72 215.55,67.6 215.43,67.57 215.37,67.67
GND_ISO on L4_POWER (solid shape): 195.15,64.69 188.9,64.69 188.9,70.94 195.15,70.94
GND_ISO on TOP: 214.1,45.95 204.65,45.95 204.65,37.52 184.68,37.52 184.68,43 172.39,43 170.69,44.7 170.92,44.93 170.92,61.8 161.21,61.8 161.21,82.78 162.69,84.25 162.69,100.96 214.1,100.96 ; 3 cut-outs
GND_ISO on BOTTOM: 185.95,95.63 189.81,95.63 189.81,100.96 214.1,100.96 214.1,46.25 204.39,46.25 204.39,37.52 184.68,37.52 184.68,43 172.44,43 170.92,44.53 170.92,61.29 170.92,61.8 161.21,61.8 161.21,82.78 163.25,84.81 163.25,92.68 162.69,93.24 162.69,100.96 178.99,100.96 178.99,95.63 179.7,95.63 179.7,93.34 181.94,93.34 181.94,95.63 182.86,95.63 182.86,98.02 185.95,98.02 ; 5 cut-outs
GND_ISO on L2_GND: 189.81,100.96 214.1,100.96 214.1,46.25 204.39,46.25 204.39,37.52 184.68,37.52 184.68,43 172.44,43 170.92,44.53 170.92,61.29 170.92,61.8 161.21,61.8 161.21,82.78 163.25,84.81 163.25,92.68 162.69,93.24 162.69,100.96 178.99,100.96 178.99,95.63 179.7,95.63 179.7,93.34 181.94,93.34 181.94,95.63 182.86,95.63 182.86,98.02 185.95,98.02 185.95,95.63 189.81,95.63
GND_ISO on L3_SIGNAL: 189.81,95.63 189.81,100.96 214.1,100.96 214.1,46.25 204.39,46.25 204.39,37.52 184.68,37.52 184.68,43 172.44,43 170.92,44.53 170.92,61.29 170.92,61.8 161.21,61.8 161.21,82.78 163.25,84.81 163.25,92.68 162.69,93.24 162.69,100.96 178.99,100.96 178.99,95.63 179.7,95.63 179.7,93.34 181.94,93.34 181.94,95.63 182.86,95.63 182.86,98.02 185.95,98.02 185.95,95.63 ; 3 cut-outs
GND_ISO on L4_POWER: outline of 133 points within 176.71,55.55 202.92,82.8
GND_ISO on L4_POWER: 182.85,74.24 182.85,65.61 181.18,65.61 181.18,74.24
GND_ISO on L4_POWER: 176.71,80.3 176.71,88.16 176.77,88.26 176.88,88.24 179.29,85.83 179.28,85.75 179.41,85.42 179.74,85.29 179.82,85.3 182.85,82.26 182.85,80.09 182.79,79.99 182.68,80.01 182.56,80.14 176.87,80.14
GND_ISO on L4_POWER: 189.81,100.96 214.1,100.96 214.1,47.12 213.23,46.25 211.96,46.25 211.96,51.49 211.51,51.94 207.14,51.94 206.43,52.66 206.43,81.09 206.62,81.28 206.71,81.31 206.79,81.24 207.16,80.71 207.77,80.5 208.5,80.81 208.8,81.53 208.8,81.62 208.79,81.7 208.81,81.78 208.89,81.81 213.18,81.81 213.18,91.47 212.57,91.47 212.49,91.5 212.47,91.58 212.47,91.67 211.51,92.63 210.54,91.67 210.54,91.62 210.54,91.58 210.52,91.5 210.44,91.47 204.29,91.47 204.29,87.1 204.08,86.89 198.69,86.89 198.6,86.96 198.62,87.07 200.13,88.57 204.14,88.57 204.14,92.58 205,93.45 208.97,93.45 208.97,99.9 208.51,100.36 193.78,100.36 192.2,98.78 192.2,97.28 189.81,97.28
GND_ISO on L4_POWER: outline of 81 points within 161.21,37.52 204.39,92.13
GND_ISO on L4_POWER: 162.69,100.96 178.99,100.96 178.99,95.63 179.7,95.63 179.7,93.34 181.94,93.34 181.94,95.63 182.86,95.63 182.86,98.02 185.95,98.02 185.95,97.28 184.78,97.28 184.78,86.18 184.72,86.09 184.61,86.11 179.17,91.55 179.17,94.83 177.22,96.77 165.89,96.77 165.89,96.78 165.89,99.8 165.49,100.2 162.98,100.2 162.86,100.08 162.75,100.06 162.69,100.15
GND_ISO on L5_POWER: 189.81,100.96 214.1,100.96 214.1,46.25 204.39,46.25 204.39,37.52 184.68,37.52 184.68,43 172.44,43 170.92,44.53 170.92,61.29 170.92,61.8 161.21,61.8 161.21,82.78 163.25,84.81 163.25,92.68 162.69,93.24 162.69,100.96 178.99,100.96 178.99,95.63 179.7,95.63 179.7,93.34 181.94,93.34 181.94,95.63 182.86,95.63 182.86,98.02 185.95,98.02 185.95,95.63 189.81,95.63 ; 7 cut-outs
GND_ISO on L6_SIGNAL: 189.81,100.96 214.1,100.96 214.1,46.25 204.39,46.25 204.39,37.52 184.68,37.52 184.68,43 172.44,43 170.92,44.53 170.92,61.29 170.92,61.8 161.21,61.8 161.21,82.78 163.25,84.81 163.25,92.68 162.69,93.24 162.69,100.96 178.99,100.96 178.99,95.63 179.7,95.63 179.7,93.34 181.94,93.34 181.94,95.63 182.86,95.63 182.86,98.02 185.95,98.02 185.95,95.63 189.81,95.63 ; 2 cut-outs
GND_ISO on L7_GND: 189.81,95.63 189.81,100.96 214.1,100.96 214.1,46.25 204.39,46.25 204.39,37.52 184.68,37.52 184.68,43 172.44,43 170.92,44.53 170.92,61.29 170.92,61.8 161.21,61.8 161.21,82.78 163.25,84.81 163.25,92.68 162.69,93.24 162.69,100.96 178.99,100.96 178.99,95.63 179.7,95.63 179.7,93.34 181.94,93.34 181.94,95.63 182.86,95.63 182.86,98.02 185.95,98.02 185.95,95.63
VBAT+ on TOP: 217.93,11.05 224.79,11.05 224.79,0.64 207.65,0.64 207.65,12.7 216.28,12.7
VBATTP on TOP: 48.54,41.48 49.3,41.48 49.3,41.73 50.42,42.85 50.42,43.87 48.69,43.87 48.54,43.71
VBATTP on TOP: 160.45,52.2 163.2,52.2 163.2,48.26 161.8,48.26 161.29,47.75 161.29,44.78 165.74,44.78 165.74,43.05 157.99,43.05 157.86,43.18 157.86,45.97 158.75,45.97 159.64,46.86 159.64,47.52 160.45,48.34
VBATTP on TOP: 82.32,95.22 82.3,95.25 73.76,95.25 73.74,95.22 73.74,88.21 76.17,88.21 77.85,89.89 82.32,89.89
VBATTP on TOP: 33.27,31.14 36.96,31.14 36.96,29.34 36.07,28.45 36.07,24 36.7,23.37 39.62,23.37 39.62,9.27 40.26,8.64 128.78,8.64 130.68,6.73 130.68,4.19 133.1,4.19 133.22,4.32 133.22,5.71 133.48,5.97 133.48,6.19 133.76,6.19 134.19,5.76 134.18,5.73 134.17,5.66 134.16,5.59 134.24,5.33 134.46,5.16 134.49,5.15 134.49,0.64 130.68,0.64 82.19,0.63 33.27,0.64
VBATTP on L4_POWER: outline of 127 points within 33.15,0.63 164.06,95.76
VBATTP on L5_POWER: 82.93,25.12 90.26,17.79 90.29,17.7 90.23,17.62 90.02,17.45 89.94,17.2 90.07,16.87 90.4,16.74 90.66,16.82 90.82,17.03 90.9,17.09 90.99,17.06 96.62,11.43 96.62,11.33 97.79,10.16 136.4,10.16 136.4,0.63 33.78,0.63 33.78,31.37 37.21,31.37 37.21,22.35 37.34,22.22 73.91,22.22 73.91,38.61 73.15,39.37 49.78,39.37 49.15,40 49.15,42.16 48.89,42.42 48.89,44.45 73.03,44.45 73.03,96.01 82.93,96.01
VBUS on TOP: 189.94,94.77 189.94,92.79 189.79,92.63 187.86,92.63 187.66,92.43 187.66,91.29 187.38,91.01 185.37,91.01 185.37,90.35 187.17,90.35 187.25,90.42 188.57,90.42 188.65,90.35 188.65,89.69 190.12,89.69 190.12,91.72 190.27,91.87 190.74,91.87 190.74,93.08 190.74,93.15 190.83,93.24 191.44,93.24 191.44,94.77
VBUS on BOTTOM: 187.63,92.94 187.63,89.64 189.97,89.64 189.97,92.94
VBUS on L4_POWER: 185.29,85.27 186.56,84 189.53,84 190.12,84.58 190.12,89.33 191.9,89.33 191.9,96.77 185.29,96.77 ; 1 cut-out
VDD on TOP: 171.53,72.82 172.57,71.78 172.57,67.16 172.42,67.01 168.48,67.01 168.12,66.65 168.12,64.87 166.6,64.87 166.6,70.97 166.95,71.32 166.95,72.72 167.06,72.82
VDD on L5_POWER: 187.83,83.24 187.83,88.39 173.99,88.39 173.61,88.01 173.61,72.26 172.14,70.79 168.68,70.79 168.63,70.74 168.63,68.61 177.52,68.61 180.16,71.25 180.16,82.78 180.62,83.24
VDDIO on TOP: 173.76,100.05 176.76,100.05 177.83,98.98 177.83,92.94 177.17,92.94 176.66,93.45 176.66,97.61 176.45,97.82 173.76,97.82
VDDIO on L4_POWER: 186.56,65.4 185.29,65.4 185.29,65.66 184.66,66.29 183.01,66.29 183.01,73.84 184.02,74.85 184.02,81.81 173.2,92.63 163.14,92.63 163.09,92.58 162.81,92.58 162.69,92.71 162.69,99.69 165.28,99.69 165.38,99.59 165.38,96.57 165.68,96.27 177.01,96.27 178.66,94.62 178.66,91.34 186.56,83.44
VDDIO on L5_POWER: 184.73,66.73 184.73,63.73 188.6,59.87 199.36,59.87 200.53,61.04 200.53,66.57 197.99,66.57 197.99,63.12 197.49,62.61 188.34,62.61 187.22,63.73 187.22,66.73
VDDIOH on L4_POWER: 177.06,73.99 180.67,73.99 180.67,65.1 186.26,65.1 186.26,63.32 187.02,62.56 195.91,62.56 196.27,62.92 196.27,65.1 198.09,65.1 198.09,61.04 177.42,61.04 177.06,61.39
BATT2_CELL16 on TOP: 115.9,30.4 115.9,32.13 116.66,32.13 116.66,30.4
BATT2_CELL16 on L5_POWER: 115.85,43.87 115.85,30.81 135.26,30.81 135.26,43.87
BMS1_DRIVE on TOP: 40.39,34.16 40.39,32.77 40.51,32.64 40.51,31.75 37.97,31.75 37.97,33.15 38.1,33.27 39.62,33.27 39.75,33.4 39.75,34.16
BMS1_DRIVE on L4_POWER: 37.72,40.13 37.72,31.5 40.06,31.5 40.06,40.13
BMS1_VREF2 on TOP: 19.94,17.65 19.94,16.76 20.19,16.51 20.19,15.62 20.96,15.62 21.08,15.75 21.08,16.51 21.34,16.76 21.34,17.65
BMS1_VREF2 on BOTTOM: 36.07,32.64 38.61,32.64 38.61,33.4 37.97,33.4 37.59,33.78 36.07,33.78
BMS1_VREF2 on L4_POWER: 30.86,32.51 21.84,23.49 21.84,15.24 18.16,15.24 18.03,15.37 18.03,33.91 18.92,34.8 37.34,34.8 37.34,32.51
BMS1_VREF2 on L5_POWER: 38.73,41.02 38.73,37.08 35.69,34.04 35.69,32.77 45.59,32.77 45.59,41.02
BMS1_VREG on TOP: 39.24,27.66 40.18,27.66 40.18,25.04 36.86,25.04 36.78,25.12 36.78,27.74 37.08,28.04 38.86,28.04
BMS1_VREG on TOP: 54.36,30.99 54.36,27.94 58.17,27.94 58.17,29.34 58.8,29.97 58.8,30.48 56.77,30.48 56.26,30.99
BMS1_VREG on L4_POWER: 40.77,38.53 40.67,38.43 40.67,30.96 37.85,30.96 37.85,29.72 36.45,28.32 36.45,23.49 55.88,23.49 55.88,36.96 52.7,36.96 52.07,36.32 46.1,36.32 44.48,37.95 44.48,45.29 44.42,45.34 34.42,45.34 34.42,43.05 39.75,43.05 40.77,42.04
BMS2_DRIVE on TOP: 118.49,34.29 120.14,34.29 120.14,33.4 120.27,33.27 120.27,32 118.75,32 118.49,32.26
BMS2_DRIVE on L4_POWER: 120.14,40.64 120.14,31.62 118.11,31.62 118.11,40.51 118.24,40.64
