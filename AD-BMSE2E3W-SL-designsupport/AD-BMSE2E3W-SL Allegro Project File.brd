# Allegro board AD-BMSE2E3W-SL Allegro Project File.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
BATT2_CELL10: length 47.7
  TOP w0.381: v1(135.68,61.85) R95.1 134.7,60.67 134.19,61.17 R96.1
  TOP w1.016: R110.1 R111.1 133.65,74.93 v1(133.65,77.09) 133.65,77.64 134.87,78.87 134.87,81.13 133.83,82.17 130.18,82.17 128.05,84.29 C101.1 129.85,88.28 P4.8
  L6_SIGNAL w0.381: v1(135.68,61.85) 135.68,75.06 v1(133.65,77.09)
BATT2_CELL11: length 44.5
  TOP w0.381: R94.1 140.76,55.67 v1(140.76,57.02)
  TOP w1.016: P4.7 133.35,84.97 135.92,82.39 C100.1 137.46,80.8 137.52,80.8 137.52,80.71 v1(141.02,77.22) 141.02,76.57 R109.1 R108.1
  L6_SIGNAL w0.381: v1(141.02,77.22) 141.02,57.28 v1(140.76,57.02)
BATT2_CELL12: length 68.6
  TOP w0.381: R93.1 139.07,52.32 R92.1 v1(139.07,51.09)
  TOP w1.016: P4.6 136.85,83.74 C99.1 138.66,81.94 141.06,79.54 C98.2 148.91,79.54 152.69,75.76 v1(152.69,67.84) R107.1 R106.1
  L3_SIGNAL w0.381: v1(139.07,51.09) 144.48,51.09 152.69,59.31 v1(152.69,67.84)
BATT2_CELL13: length 69.2
  TOP w0.381: R91.1 v1(140.72,45.89)
  TOP w0.508: 155.19,57.49 v1(154.6,56.9)
  TOP w1.016: P4.5 140.35,83.81 143.02,81.14 C98.1 145.08,81.11 C97.2 149.32,81.11 155.19,75.24 155.19,57.4 154.18,56.39 R105.1 R104.1
  L3_SIGNAL w0.381: v1(140.72,45.89) 142.28,45.89 153.29,56.9 v1(154.6,56.9)
BATT2_CELL14: length 77.8
  TOP w0.381: v1(139.41,44.96) R89.1 138.56,45.72 R90.1
  TOP w1.016: R102.1 R103.1 154.18,47.24 v1(155.45,48.51) 156.46,49.53 156.46,76.12 C96.2 149.87,82.72 C97.1 145.12,82.72 143.85,83.99 P4.4
  L3_SIGNAL w0.381: v1(155.45,48.51) 155.45,48.13 152.27,44.96 v1(139.41,44.96)
BATT2_CELL15: length 96.3
  TOP w0.381: v1(137.04,38.9) R88.1 ; 154.93,40.46 154.94,40.47 v1(154.94,40.51)
  TOP w0.508: D24.A v1(158.15,86.22)
  TOP w1.016: R100.1 R101.1 154.93,40.46 154.93,46.09 157.73,48.89 157.73,77.08 C95.2 152.81,82.01 151.49,83.33 C96.1 147.35,87.5 P4.3
  L3_SIGNAL w0.381: v1(137.04,38.9) 153.33,38.9 v1(154.94,40.51)
  BOTTOM w0.508: P4.3 151.91,84.59 156.53,84.59 v1(158.15,86.22)
BATT2_CELL16: length 130.8
  TOP w0.508: R87.1 133.73,39.37 v1(134.37,38.73) ; R143.1 128.61,42.25 v1(129.15,42.8) ; v1(116.29,31.88) R144.1
  TOP w0.762: P4.1 154.77,89.57 R342.1 R340.1
  TOP w1.016: R99.1 153.16,29.08 v1(154.94,30.86) 155.32,31.24 155.32,38.35 156.46,39.5 156.46,45.72 159.13,48.39 159.13,77.98 153.98,83.13 153.94,83.13 150.85,86.23 P4.2 P4.1
  L3_SIGNAL w0.381: v1(134.37,38.73) 135.38,38.73 137.41,36.7 149.1,36.7 v1(154.94,30.86)
  L4_POWER w0.508: v1(134.37,38.73) 134.37,40.51 132.08,42.8 v1(129.15,42.8)
  L6_SIGNAL w0.508: v1(129.15,42.8) 129.15,41.01 127.33,39.19 127.33,37.54 121.28,31.5 116.67,31.5 v1(116.29,31.88)
BMS1_C1: length 8.8
  TOP w0.254: U1.57 30.6,46.03 30.6,46.02 30.11,46.02 30.11,46.03 29.5,46.03 C40.2 27.61,46.32 R41.2
BMS1_C2: length 7.3
  TOP w0.254: U1.51 32.74,49.03 32.4,49.36 31.06,49.36 C39.1 30.82,49.71 R39.2
BMS1_C2_1: length 12.1
  TOP w0.203: C39.2 29.21,49.62 C40.1
  TOP w0.254: U1.54 31.47,47.53 31.08,47.92 C40.1 ; C39.2 R40.2 27.65,51.26 C304.1
BMS1_C3: length 12.3
  TOP w0.203: 30.65,53.3 30.61,53.34 29.38,53.34 C38.2
  TOP w0.254: R38.2 29.3,53.34 C38.2 30.65,53.3 31.88,52.07 31.88,50.42 32.46,49.83 32.72,49.83 33.02,49.53 U1.50
BMS1_C4: length 9.3
  TOP w0.254: R36.2 30.95,56.69 C37.1 31.75,56.64 32.05,56.34 32.05,55.19 34.72,52.53 U1.44
BMS1_C4_3: length 13.5
  TOP w0.254: C311.1 27.6,56.69 R37.2 C37.2 29.3,54.94 C38.1 29.81,54.9 33.07,51.64 33.08,51.64 33.69,51.03 U1.47
BMS1_C5: length 13.1
  TOP w0.254: U1.43 35.11,53.03 32.51,55.63 32.51,60.54 C36.2 31.11,62.01 R35.2
BMS1_C6: length 7.7
  TOP w0.203: R33.2 36.02,60.29 C35.1
  TOP w0.254: U1.37 39.55,57.1 38.1,58.55 37.76,58.55 R33.2
BMS1_C6_5: length 14.6
  TOP w0.203: C307.1 36.02,63.41 R34.2 C35.2 34.33,61.98 C36.1 33.15,61.51 33.15,58.55 35.8,55.9 U1.40
BMS1_C7: length 8.7
  TOP w0.254: U1.36 40.05,57.36 37.93,59.47 C34.2 37.93,63.63 R32.2
BMS1_C8: length 6.4
  TOP w0.254: U1.30 43.05,60.37 R30.2 41.2,60.49 C33.1
BMS1_C8_7: length 11.9
  TOP w0.254: U1.33 41.55,58.27 39.54,60.29 C34.1 39.57,62.14 C33.2 41.15,63.54 R31.2 42.88,63.67 C314.1
BMS1_C9: length 8.1
  TOP w0.254: R13.2 45.81,62.61 C16.2 45.09,61.09 43.55,59.55 U1.29
BMS1_C10: length 6.7
  TOP w0.254: R11.2 49.33,59.48 C15.1 48.77,59.52 46.55,57.31 U1.23
BMS1_C10_9: length 11.2
  TOP w0.254: C302.1 49.33,62.7 R12.2 C15.2 47.45,61.13 C16.1 47.41,60.74 45.05,58.38 U1.26
BMS1_C11: length 12.5
  TOP w0.254: C14.2 56.01,58.97 R10.2 52.49,58.97 51.56,58.04 48.13,58.04 47.05,56.95 U1.22
BMS1_C12: length 9.1
  TOP w0.254: U1.16 51.77,52.03 53.72,53.97 R8.2 56.05,55.58 C13.1
BMS1_C12_11: length 14.9
  TOP w0.254: U1.19 50.48,53.53 54.32,57.37 C14.1 57.66,55.66 C13.2 R9.2 59.35,54.02 C190.1
BMS1_C13: length 8.5
  TOP w0.254: U1.15 52.16,51.53 52.74,52.11 C12.2 56.17,52.07 R7.2
BMS1_C14: length 8.4
  TOP w0.254: R5.2 56.1,46.91 C11.1 49.43,48.51 U1.9
BMS1_C14_13: length 12.9
  TOP w0.254: U1.12 53.58,50.03 54.06,50.51 C12.1 57.7,48.95 C11.2 C191.1 59.35,48.46 R6.2
BMS1_C15: length 10.3
  TOP w0.254: R4.2 55.66,44.96 C10.2 55.24,45.38 55.24,47.5 54.72,48.03 U1.8
BMS1_C16: length 7.3
  TOP w0.254: R2.2 52.36,41.61 C9.1 52.41,43.5 50.88,45.03 U1.2
BMS1_C16_15: length 12.7
  TOP w0.254: C9.2 C299.1 ; C299.1 55.71,43.31 C10.1 52.5,46.53 U1.5 ; C299.1 55.71,40.05 R3.2
BMS1_DRIVE: length 7
  TOP w0.254: U1.65 40.05,41.32 38.65,39.92 v1(38.35,39.92)
  TOP w0.508: R61.1 40.04,32.31 C68.1 39.37,32.26 39.12,32 v1(38.99,32) v1(38.35,32)
BMS1_GPIO7: length 55.3
  TOP w0.254: R64.1 17.27,14.95 C72.1 v1(17.31,16) ; U1.74 44.55,41.72 44.58,41.69 44.58,37.46 v1(44.96,37.08)
  L3_SIGNAL w0.254: v1(44.96,37.08) 44.7,36.83 20.07,36.83 17.31,34.07 v1(17.31,16)
BMS1_GPIO7_INPUT: length 8
  TOP w0.254: R64.2 R72.2 15.62,10.2 C80.1 17.92,7.82 P3.1
BMS1_GPIO8: length 58.8
  TOP w0.254: R66.1 12.15,13.46 C74.1 v1(12.15,16) ; v1(43.43,38.35) 44.05,38.97 44.05,42.66 U1.73
  L3_SIGNAL w0.254: v1(43.43,38.35) 42.93,37.85 15.11,37.85 12.15,34.89 v1(12.15,16)
BMS1_GPIO8_INPUT: length 8.4
  TOP w0.254: P3.3 15.38,6.93 C82.1 12.19,10.2 R66.2 R74.2
BMS1_GPIO9: length 60.1
  TOP w0.254: U1.72 43.56,42.64 43.56,39.62 v1(43.18,39.24) ; v1(10.45,16) C76.1 10.45,13.46 R68.1
  L3_SIGNAL w0.254: v1(10.45,16) 10.45,16.22 9.4,17.27 9.4,33.15 14.73,38.48 42.42,38.48 v1(43.18,39.24)
BMS1_GPIO9_INPUT: length 8.9
  TOP w0.254: R68.2 R76.2 8.72,11.69 C84.1 12.57,6.32 P3.5
BMS1_GPIO10: length 61.6
  TOP w0.254: v1(5.33,16) 5.33,15.02 C78.1 5.3,13.46 R70.1 ; v1(42.93,40.13) 43.05,40.25 U1.71
  L3_SIGNAL w0.254: v1(5.33,16) 5.33,30.99 13.46,39.12 41.91,39.12 v1(42.93,40.13)
BMS1_GPIO10_INPUT: length 9.8
  TOP w0.254: R78.2 R70.2 5.33,10.2 C86.1 9.14,6.32 P3.7
BMS1_I2C_SCL: length 20
  TOP w0.254: U1.76 45.55,38.78 46.71,37.62 v1(48.01,37.62) ; v1(53.68,32.35) R60.2 55.28,32.77 U2.6
  L6_SIGNAL w0.254: v1(53.68,32.35) 52.4,33.63 52.4,35.33 50.11,37.62 v1(48.01,37.62)
BMS1_I2C_SDA: length 18.3
  TOP w0.254: v1(47.37,38.33) 47.35,38.31 46.99,38.31 46.05,39.24 U1.77 ; v1(53.59,34.16) 54.7,34.16 R62.2 56.6,34.33 56.9,34.04 57.78,34.04
  L6_SIGNAL w0.254: v1(47.37,38.33) 50.77,38.33 53.59,35.51 v1(53.59,34.16)
BMS1_IMA: length 14.8
  TOP w0.254: R79.1 24.85,40.23 C87.1 30.15,45.53 U1.58
BMS1_IMA_ISO: length 92.8
  TOP w0.203: 23.5,21.25 T1.1 ; 110.4,21.89 T2.6
  TOP w0.254: v1(110.4,20.49) 110.4,21.89 ; v1(23.5,19.68) 23.5,21.25
  L6_SIGNAL w0.254: v1(110.4,20.49) 108.92,21.97 101.09,21.97 98.68,19.56 83.19,19.56 81.92,18.29 28.07,18.29 26.47,19.89 23.7,19.89 v1(23.5,19.68)
BMS1_IMB: length 8
  TOP w0.254: U1.62 38.55,41.98 38.53,41.96 38.53,41.94 38.34,41.74 38.31,41.74 38.25,41.68 34.69,41.68 C88.1 33.27,39.02 R80.1
BMS1_IMB_ISO: length 169.9
  TOP w0.203: 176.05,35.25 T5.3 ; 29.84,21.25 T1.6
  TOP w0.254: 176.05,35.25 176.05,34.39 v1(176.91,33.53) ; v1(29.84,19.56) 29.84,21.25
  L3_SIGNAL w0.254: v1(29.84,19.56) 30.68,19.56 32.44,17.81 81,17.81 90.04,8.76 111,8.76 124.33,22.1 172.85,22.1 176.91,26.16 v1(176.91,33.53)
BMS1_IPA: length 12.6
  TOP w0.254: U1.59 30.93,45.03 27.69,41.79 C89.1 27.69,39.02 R81.1
BMS1_IPA_ISO: length 92
  TOP w0.203: 112.94,21.89 T2.8 ; 26.04,21.25 T1.3
  TOP w0.254: v1(26.04,19.18) 26.04,21.25 ; v1(112.94,20.57) 112.94,21.89
  L6_SIGNAL w0.254: v1(112.94,20.57) 111.8,19.43 101.47,19.43 99.87,17.83 27.38,17.83 v1(26.04,19.18)
BMS1_IPB: length 6.1
  TOP w0.254: U1.63 39.05,41.61 38.66,41.22 36.58,41.22 36.08,40.72 C90.1 36.11,40.23 R82.1
BMS1_IPB_ISO: length 153.3
  TOP w0.203: 173.51,35.25 T5.1 ; 32.38,21.25 T1.8
  TOP w0.254: v1(32.38,19.43) 32.38,21.25 ; 173.51,35.25 173.51,33.68 v1(173.48,33.65)
  L6_SIGNAL w0.254: v1(32.38,19.43) 33.25,20.29 97.76,20.29 100.33,22.86 167.51,22.86 173.48,28.83 v1(173.48,33.65)
BMS1_NTC1: length 18.2
  TOP w0.254: v1(47.93,41.68) 47.55,42.06 U1.80
  L3_SIGNAL w0.254: v1(60.74,37.31) 60.59,37.46 56.06,37.46 51.84,41.68 v1(47.93,41.68)
  BOTTOM w0.254: v1(60.74,37.31) C71.1 60.74,34.92 R63.1
BMS1_NTC2: length 14.2
  TOP w0.254: U1.79 47.05,40.33 48.39,38.99 53.47,38.99 v1(55.12,37.34)
  BOTTOM w0.254: v1(55.12,37.34) 54.95,37.17 C73.1 54.99,36.28 R65.1
BMS1_NTC3: length 9.3
  TOP w0.254: v1(46.86,39.5) 46.81,39.5 46.55,39.76 U1.78
  BOTTOM w0.254: R67.1 45.47,35.98 C75.1 46.1,36.07 46.41,36.37 46.41,39.04 v1(46.86,39.5)
BMS1_NTC4: length 13.2
  TOP w0.254: U1.75 45.05,38.01 45.34,37.72 v1(45.47,37.72)
  BOTTOM w0.254: v1(45.47,37.72) 40.89,37.72 39.97,36.79 C77.1 40.01,36.03 R69.1
BMS1_S1N: length 50.4
  TOP w0.254: v1(30.78,47.18) 30.93,47.03 U1.55
  TOP w0.381: v1(25.02,44.32) 23.79,44.32 C48.2 23.75,41.53 22.23,40 22.23,33.15 20.84,31.76 20.84,22.2 R57.2 16.36,19.05 15.31,20.1 v1(15.31,22.99)
  L3_SIGNAL w0.381: v1(30.78,47.18) 30.93,47.18 31.48,46.62 31.48,45.07 30.73,44.32 v1(25.02,44.32)
  BOTTOM w0.381: D36.2 v1(15.31,22.99)
BMS1_S1P: length 49.7
  TOP w0.254: v1(30.35,46.61) 30.44,46.53 U1.56
  TOP w0.381: v1(25.11,45.89) C48.1 22.99,45.89 22.61,45.5 22.61,41.91 21.59,40.89 21.59,33.53 20.19,32.13 v1(20.19,26.16) 20.19,25.65 18.16,23.62 R56.2
  L3_SIGNAL w0.381: v1(30.35,46.61) 29.63,45.89 v1(25.11,45.89)
  BOTTOM w0.381: D36.1 17.56,24.91 C64.1 19.71,24.92 20.19,25.4 v1(20.19,26.16) 20.19,26.76 19.81,27.14 C63.2 ; v1(25.11,45.89) C48.1
BMS1_S2N: length 39.4
  TOP w0.254: v1(32.16,48.78) 32.41,48.53 U1.52
  TOP w0.381: v1(25.27,47.88) 23.79,47.88 C47.2 21.97,46.06 21.97,42.29 20.96,41.27 20.96,33.91 19.66,32.61 19.66,32.42 19.61,32.37 19.61,29.98 R55.2 16.43,26.8 v1(15.41,26.8)
  L3_SIGNAL w0.381: v1(32.16,48.78) 32.16,48.26 31.77,47.88 v1(25.27,47.88)
  BOTTOM w0.381: D41.2 v1(15.41,26.8)
BMS1_S2P: length 49.2
  TOP w0.254: v1(31.24,48.64) 31.86,48.03 U1.53
  TOP w0.381: v1(24.89,49.4) 23.79,49.4 C47.1 22.9,49.44 22.23,48.77 22.23,47.14 21.21,46.13 21.21,42.67 20.19,41.66 v1(20.19,34.29) 18.41,32.51 R54.2
  L3_SIGNAL w0.381: v1(24.89,49.4) 25.27,49.02 30.86,49.02 v1(31.24,48.64)
  BOTTOM w0.381: C62.2 19.61,36.78 20.19,36.19 v1(20.19,34.29) 20.19,31.28 C63.1 17.63,28.72 D41.1 ; v1(24.89,49.4) 23.79,49.4 C47.1
BMS1_S3N: length 38.7
  TOP w0.254: v1(32.64,51.18) 32.89,51.18 33.55,50.53 U1.48
  TOP w0.381: v1(15.46,36.46) 17.19,36.46 R53.2 19.61,38.87 19.61,42.09 20.57,43.05 20.57,46.74 21.64,47.8 21.64,51.07 22.1,51.52 C46.2 v1(24.77,51.52)
  L3_SIGNAL w0.381: v1(24.77,51.52) 27.67,51.52 29.54,49.66 33.53,49.66 33.96,50.09 33.96,50.62 33.4,51.18 v1(32.64,51.18)
  BOTTOM w0.381: D39.2 v1(15.46,36.46)
BMS1_S3P: length 46.4
  TOP w0.254: v1(32.77,50.42) 32.89,50.29 32.9,50.29 33.17,50.03 U1.49
  TOP w0.381: v1(19.68,43.43) 19.68,46.74 21.06,48.11 21.06,52.55 21.63,53.12 C46.1 v1(24.6,53.12) ; v1(19.68,43.43) 17.69,41.44 ; v1(19.68,43.43) 17.69,41.44 ; R52.2 17.69,41.44
  L3_SIGNAL w0.381: v1(32.77,50.42) 30.71,50.42 28,53.12 v1(24.6,53.12)
  BOTTOM w0.381: C310.1 24.47,53 v1(24.6,53.12) ; D39.1 17.55,38.37 C62.1 17.93,38.38 19.68,40.13 v1(19.68,43.43) 19.68,44.96 18.84,45.8 C61.2
BMS1_S4N: length 31.4
  TOP w0.254: U1.45 34.46,52.03 v1(30.86,55.63)
  TOP w0.381: v1(24.68,56.48) C45.2 22.95,56.48 20.33,53.86 20.33,50.53 20.32,50.52 20.32,48.89 17.69,46.27 R51.2 17.22,45.5 v1(15.36,45.5)
  L3_SIGNAL w0.381: v1(30.86,55.63) 30.01,56.48 v1(24.68,56.48)
  BOTTOM w0.381: D35.2 v1(15.36,45.5)
BMS1_S4P: length 42.3
  TOP w0.254: v1(30.99,54.61) 34.07,51.53 U1.46
  TOP w0.381: v1(24.64,57.91) 23.79,57.91 C45.1 23.03,58.08 19.68,54.74 v1(19.68,50.8) 19.3,50.42 R50.2
  L3_SIGNAL w0.381: v1(30.99,54.61) 31.75,55.37 31.75,56.69 30.53,57.91 v1(24.64,57.91)
  BOTTOM w0.381: C60.2 19.68,52.57 v1(19.68,50.8) 19.68,49.52 C61.1 17.55,47.41 D35.1 ; v1(24.64,57.91) 23.66,57.91 C313.1
BMS1_S5N: length 28.6
  TOP w0.254: U1.41 35.64,54.03 v1(34.54,55.12)
  TOP w0.381: v1(15.37,53.72) 16.51,53.72 17.69,54.9 R49.2 17.69,55.03 22.69,60.03 C44.2 25.57,60.07 v1(26.8,60.07)
  L3_SIGNAL w0.381: v1(26.8,60.07) 29.9,60.07 32.88,57.09 32.88,55.23 33.26,54.85 34.28,54.85 v1(34.54,55.12)
  BOTTOM w0.381: D34.2 14.7,54.39 v1(15.37,53.72)
BMS1_S5P: length 38
  TOP w0.254: U1.42 35.26,53.53 33.78,55 v1(33.78,55.63)
  TOP w0.381: R48.2 17.95,59.69 v1(19.81,59.69) 21.76,61.63 C44.1 26.76,61.63 v1(26.8,61.59)
  L3_SIGNAL w0.381: v1(33.78,55.63) 33.78,57.66 29.84,61.59 v1(26.8,61.59)
  BOTTOM w0.381: v1(26.8,61.59) 25.57,61.59 C44.1 ; D34.1 17.55,56.3 C60.1 19.81,58.54 v1(19.81,59.69) 19.81,61.71 C59.2
BMS1_S6N: length 28.8
  TOP w0.254: v1(35.05,57.91) 38.09,57.91 39.05,56.95 U1.38
  TOP w0.381: v1(26.63,63.33) C43.2 25.49,63.37 24.13,63.37 23.5,64.01 R47.2 17.34,63.53 v1(15.56,63.53)
  L3_SIGNAL w0.381: v1(35.05,57.91) 29.63,63.33 v1(26.63,63.33)
  BOTTOM w0.381: D40.2 v1(15.56,63.53)
BMS1_S6P: length 41.8
  TOP w0.254: v1(35.81,57.28) 37.97,57.28 38.55,56.7 U1.39
  TOP w0.381: R46.2 v1(18.41,68.07) 21.55,64.94 C43.1 25.57,64.9 v1(26.54,64.9)
  L3_SIGNAL w0.381: v1(35.81,57.28) 35.81,58.98 30.2,64.59 26.85,64.59 v1(26.54,64.9)
  BOTTOM w0.381: C43.1 25.57,64.9 v1(26.54,64.9) ; C58.2 19.14,70.83 18.41,70.1 v1(18.41,68.07) 18.41,66.16 C59.1 17.68,65.45 D40.1
BMS1_S7N: length 30
  TOP w0.254: v1(38.87,60.26) 41.05,58.09 U1.34
  TOP w0.381: v1(21.62,72.41) 22.86,71.17 R45.2 26.12,66.93 C42.2 27.69,66.89 v1(27.69,65.79)
  L6_SIGNAL w0.381: v1(27.69,65.79) 30.35,63.12 36.02,63.12 v1(38.87,60.26)
  BOTTOM w0.381: D38.2 v1(21.62,72.41)
BMS1_S7P: length 40.2
  TOP w0.254: v1(38.99,59.31) 40.55,57.75 U1.35
  TOP w0.381: v1(29.34,65.79) 29.34,66.84 C42.1 29.25,67.56 28.74,68.07 v1(27.3,68.07) R44.2
  L6_SIGNAL w0.381: v1(38.99,59.31) 39.5,59.31 40.01,59.82 40.01,60.83 36.58,64.26 30.86,64.26 v1(29.34,65.79)
  BOTTOM w0.381: v1(29.34,65.79) 29.25,65.87 C42.1 ; D38.1 23.54,70.84 C58.1 23.53,69.95 25.4,68.07 v1(27.3,68.07) 29.72,68.07 30.94,69.3 C57.2
BMS1_S8N: length 25.2
  TOP w0.254: U1.31 42.55,59.18 42.15,59.58 v1(41.26,59.58)
  TOP w0.381: v1(30.61,72.46) 31.75,71.32 R43.2 31.75,68.41 C41.2 v1(33.11,66.04)
  L6_SIGNAL w0.381: v1(33.11,66.04) 33.95,65.2 37.41,65.2 41.26,61.35 v1(41.26,59.58)
  BOTTOM w0.381: D37.2 v1(30.61,72.46)
BMS1_S8P: length 34.5
  TOP w0.254: U1.32 42.05,58.66 v1(41.78,58.93)
  TOP w0.381: v1(34.67,66.08) 34.71,66.12 C41.1 35.18,67.06 v1(36.2,68.07) R42.2
  L6_SIGNAL w0.381: v1(34.67,66.08) 34.94,65.81 37.67,65.81 42.04,61.44 42.04,59.18 v1(41.78,58.93)
  BOTTOM w0.381: v1(34.67,66.08) 34.67,67.02 C41.1 ; D37.1 32.53,70.84 C57.1 32.54,68.93 33.4,68.07 v1(36.2,68.07) 37.08,68.07 C56.2
BMS1_S9N: length 22.7
  TOP w0.254: U1.27 44.55,58.82 45.03,59.31 v1(45.09,59.31)
  TOP w0.381: v1(44.67,65.37) C24.2 42.8,66.55 40.64,68.71 R29.2 39.5,71.33 v1(39.5,72.47)
  L6_SIGNAL w0.381: v1(44.67,65.37) 43.51,64.21 43.51,60.17 44.37,59.31 v1(45.09,59.31)
  BOTTOM w0.381: D25.2 v1(39.5,72.47)
BMS1_S9P: length 31.7
  TOP w0.254: U1.28 44.05,59.16 v1(44.96,60.07)
  TOP w0.381: v1(46.1,65.4) 46.27,65.57 C24.1 46.27,67.65 45.85,68.07 v1(45.09,68.07) R28.2
  L6_SIGNAL w0.381: v1(46.1,65.4) 44.96,64.26 v1(44.96,60.07)
  BOTTOM w0.381: C55.2 48.6,69.17 47.5,68.07 v1(45.09,68.07) 42.04,68.07 41.44,68.67 C56.1 41.42,70.84 D25.1 ; C24.1 46.1,66.38 v1(46.1,65.4)
BMS1_S10N: length 24.1
  TOP w0.254: v1(48.25,59.83) 46.05,57.63 U1.24
  TOP w0.381: v1(48.26,72.39) 48.29,72.36 48.29,71.21 49.31,70.19 R27.2 53.3,66.42 C23.2 53.34,64.1 v1(53.34,62.99)
  L6_SIGNAL w0.381: v1(48.25,59.83) 50.18,59.83 v1(53.34,62.99)
  BOTTOM w0.381: D26.2 48.29,72.42 v1(48.26,72.39)
BMS1_S10P: length 37.6
  TOP w0.254: v1(47.24,59.69) 45.55,58 U1.25
  TOP w0.381: v1(54.9,63.08) C23.1 54.9,67.27 v1(54.1,68.07) 54.1,70.07 R26.2
  L6_SIGNAL w0.381: v1(47.24,59.69) 48.01,58.93 51.05,58.93 54.9,62.78 v1(54.9,63.08)
  BOTTOM w0.381: D26.1 50.21,70.71 C55.1 50.2,68.67 50.8,68.07 v1(54.1,68.07) 56.39,68.07 57.75,69.43 C54.2 ; v1(54.9,63.08) 54.9,64.07 C303.1
BMS1_S11N: length 27.4
  TOP w0.254: U1.20 49.42,54.75 v1(49.91,55.24)
  TOP w0.381: v1(57.24,63.12) C22.2 57.24,68.88 R25.2 58.55,71.36 v1(57.44,72.47)
  L6_SIGNAL w0.381: v1(49.91,55.24) 49.1,56.06 49.1,57.74 49.66,58.29 54.61,58.29 57.21,60.9 57.21,63.09 v1(57.24,63.12)
  BOTTOM w0.381: D27.2 v1(57.44,72.47)
BMS1_S11P: length 39.7
  TOP w0.254: v1(49.91,57.28) 48.13,57.28 47.55,56.69 U1.21
  TOP w0.381: v1(58.8,63.12) 58.8,64.1 C22.1 62.99,68.29 62.99,68.33 ; R24.2 62.99,68.33 ; 62.99,68.33 v1(62.94,68.27)
  L6_SIGNAL w0.381: v1(58.8,63.12) 58.8,61.09 54.99,57.28 v1(49.91,57.28)
  BOTTOM w0.381: C22.1 58.8,64.1 v1(58.8,63.12) ; C53.2 66.76,69.43 65.61,68.27 v1(62.94,68.27) 60.51,68.27 59.35,69.43 C54.1 59.35,70.87 D27.1
BMS1_S12N: length 36
  TOP w0.254: U1.17 51.38,52.53 52.7,53.85 v1(52.7,53.97)
  TOP w0.381: v1(66.43,72.31) 66.43,71.33 R23.2 67.4,70.19 63.25,66.04 v1(63.25,56.77) C21.2
  L3_SIGNAL w0.381: v1(63.25,56.77) 60.45,53.97 v1(52.7,53.97)
  BOTTOM w0.381: D28.2 v1(66.43,72.31)
BMS1_S12P: length 45.8
  TOP w0.254: U1.18 50.99,53.03 v1(51.56,53.59)
  TOP w0.381: R22.2 68.16,65.15 v1(66.04,65.15) 64.26,63.37 64.26,54.44 63.88,54.06 C21.1 63.21,54.1 v1(62.23,54.1)
  L3_SIGNAL w0.381: v1(51.56,53.59) 52.07,53.09 61.21,53.09 v1(62.23,54.1)
  BOTTOM w0.381: C52.2 66.89,60.87 66.04,61.72 v1(66.04,65.15) 68.36,67.48 C53.1 68.34,70.76 D28.1 ; v1(62.23,54.1) 63.21,54.1 C21.1
BMS1_S13N: length 30.9
  TOP w0.254: v1(53.59,50.93) 53.19,50.53 U1.13
  TOP w0.381: v1(60.74,51.98) C20.2 63.41,51.98 65.15,53.72 65.15,59.82 66.17,60.83 R21.2 70.25,60.83 v1(70.59,61.18)
  L3_SIGNAL w0.381: v1(53.59,50.93) 53.59,51.6 54.14,52.15 58.6,52.15 58.95,51.79 60.55,51.79 v1(60.74,51.98)
  BOTTOM w0.381: D29.2 v1(70.59,61.18)
BMS1_S13P: length 39.2
  TOP w0.254: v1(54.36,51.43) 54.28,51.51 53.04,51.51 52.55,51.03 U1.14
  TOP w0.381: R20.2 66.42,56.39 v1(65.91,55.88) 65.91,53.21 63.08,50.38 C20.1 60.87,50.38 v1(60.83,50.42)
  L3_SIGNAL w0.381: v1(54.36,51.43) 57.99,51.43 59,50.42 v1(60.83,50.42)
  BOTTOM w0.381: C51.2 66.76,51.98 65.91,52.83 v1(65.91,55.88) 65.91,58.8 66.38,59.27 C52.1 67.95,59.27 D29.1 ; C20.1 60.87,50.38 v1(60.83,50.42)
BMS1_S14N: length 25.2
  TOP w0.254: U1.10 54.74,49.03 v1(55.12,49.4)
  TOP w0.381: v1(70.54,52.29) 70.2,51.94 R19.2 65.91,51.94 63.63,49.66 C19.2 62.4,48.43 v1(62.36,48.39)
  L3_SIGNAL w0.381: v1(55.12,49.4) 61.34,49.4 v1(62.36,48.39)
  BOTTOM w0.381: D30.2 v1(70.54,52.29)
BMS1_S14P: length 36.3
  TOP w0.254: U1.11 54.1,49.53 v1(54.23,49.66)
  TOP w0.381: R18.2 v1(65.66,47.24) 64.05,47.24 C19.1 63.59,46.86 v1(62.36,46.86)
  L3_SIGNAL w0.381: v1(62.36,46.86) 62.36,47.37 61.09,48.64 54.61,48.64 54.23,49.02 v1(54.23,49.66)
  BOTTOM w0.381: C19.1 63.59,46.86 v1(62.36,46.86) ; C50.2 65.66,45.25 v1(65.66,47.24) 65.66,50 66.04,50.38 C51.1 67.95,50.38 D30.1
BMS1_S15N: length 25.2
  TOP w0.254: v1(54.36,46.35) 53.72,46.35 53.05,47.03 U1.6
  TOP w0.381: v1(70.58,43.4) 69.98,42.8 R17.2 66.67,42.8 64.73,44.74 C18.2 60.88,44.74 v1(59.7,43.55)
  L3_SIGNAL w0.381: v1(54.36,46.35) 56.52,44.2 59.05,44.2 v1(59.7,43.55)
  BOTTOM w0.381: D31.2 v1(70.58,43.4)
BMS1_S15P: length 40.1
  TOP w0.254: U1.7 53.57,47.53 v1(53.72,47.37)
  TOP w0.381: R16.2 66.93,38.23 v1(65.66,39.5) 62.01,43.14 C18.1 61.68,43.18 v1(60.71,43.18)
  L3_SIGNAL w0.381: v1(53.72,47.37) 53.34,46.99 53.34,45.59 56.13,42.8 60.33,42.8 v1(60.71,43.18)
  BOTTOM w0.381: D31.1 67.82,41.49 C50.1 66.04,41.49 65.66,41.11 v1(65.66,39.5) 65.66,36.11 C49.2 ; v1(60.71,43.18) 60.74,43.14 C18.1
BMS1_S16N: length 28.3
  TOP w0.254: v1(53.21,43.43) 51.12,45.53 U1.3
  TOP w0.381: v1(58.59,41.69) C17.2 61.56,41.69 66.04,37.21 66.04,35.56 67.95,33.65 R15.2 69.99,33.65 v1(70.49,34.16)
  L3_SIGNAL w0.381: v1(58.59,41.69) 55.84,41.69 54.1,43.43 v1(53.21,43.43)
  BOTTOM w0.381: D32.2 v1(70.49,34.16)
BMS1_S16P: length 39.9
  TOP w0.254: U1.4 51.76,46.03 v1(52.07,45.72)
  TOP w0.381: C17.1 v1(60.83,40.09) 61.76,40.09 65.41,36.45 v1(65.41,32.22) 65.41,29.84 66.17,29.08 R14.2
  L3_SIGNAL w0.381: v1(52.07,45.72) 52.07,43.05 54.99,40.13 60.79,40.13 v1(60.83,40.09)
  BOTTOM w0.381: C17.1 v1(60.83,40.09) ; v1(65.41,32.22) C49.1 67.97,32.24 D32.1
BMS1_VREF2: length 8.2
  TOP w0.254: v1(40.51,40.13) 40.51,40.39 41.55,41.42 U1.68
  TOP w0.508: C66.1 41.78,37.76 40.51,39.03 v1(40.51,40.13)
  L3_SIGNAL w0.508: v1(36.96,33.4) v1(36.32,33.4)
  BOTTOM w0.508: E2.1 37.35,33.01 v1(36.96,33.4)
  vias: v1(20.32,17.27) v1(20.96,17.27)
BMS1_VREG: length 10.1
  TOP w0.203: 54.79,30.57 R60.1
  TOP w0.254: U1.69 42.05,41.16 41.4,40.51 v1(41.4,40) ; U1.60 35.13,44.53 34.8,44.2 v1(34.8,43.56)
  TOP w0.508: R62.1 54.27,36.03 v1(53.85,36.45) ; C70.1 E1.2 TP2.1
  vias: v1(38.1,25.91) v1(38.1,25.27) v1(38.73,25.91) v1(38.73,25.27) v1(54.79,29.64) v1(54.79,28.93) v1(55.45,29.64) v1(55.45,28.93)
BMS2_C1: length 8.8
  TOP w0.254: R126.2 107.28,46.32 C134.2 109.17,46.03 109.78,46.03 109.78,46.02 110.27,46.02 110.27,46.03 U3.57
BMS2_C2: length 7.3
  TOP w0.254: R124.2 110.49,49.71 C133.1 110.74,49.36 112.07,49.36 112.41,49.03 U3.51
BMS2_C2_1: length 12.1
  TOP w0.203: C133.2 108.88,49.62 C134.1
  TOP w0.254: C134.1 110.75,47.92 111.14,47.53 U3.54 ; C333.1 107.32,51.26 R125.2 C133.2
BMS2_C3: length 11
  TOP w0.254: U3.50 112.69,49.53 112.39,49.83 112.13,49.83 111.55,50.42 111.55,52.07 110.32,53.3 C132.2 108.97,53.34 R123.2
BMS2_C4: length 9.3
  TOP w0.254: R121.2 110.57,58.24 C131.1 111.42,56.64 111.73,56.34 111.73,55.19 114.39,52.53 U3.44
BMS2_C4_3: length 13.5
  TOP w0.254: C338.1 107.27,56.69 R122.2 C131.2 108.97,54.94 C132.1 109.48,54.9 112.74,51.64 112.75,51.64 113.37,51.03 U3.47
BMS2_C5: length 13.1
  TOP w0.254: R120.2 110.79,62.01 C130.2 112.18,60.54 112.18,55.63 114.78,53.03 U3.43
BMS2_C6: length 7.7
  TOP w0.203: R118.2 115.69,60.29 C129.1
  TOP w0.254: R118.2 117.43,58.55 117.77,58.55 119.22,57.1 U3.37
BMS2_C6_5: length 14.6
  TOP w0.203: U3.40 115.47,55.9 112.82,58.55 112.82,61.51 C130.1 114,61.98 C129.2 R119.2 115.69,63.41 C340.1
BMS2_C7: length 8.7
  TOP w0.254: R117.2 117.61,63.63 C128.2 117.61,59.47 119.72,57.36 U3.36
BMS2_C8: length 6.4
  TOP w0.254: U3.30 122.72,60.37 R115.2 120.87,60.49 C127.1
BMS2_C8_7: length 11.9
  TOP w0.254: C330.1 122.55,63.67 R116.2 120.82,63.54 C127.2 119.24,62.14 C128.1 119.21,60.29 121.22,58.27 U3.33
BMS2_C9: length 8.1
  TOP w0.254: R98.2 125.48,62.61 C110.2 124.76,61.09 123.22,59.55 U3.29
BMS2_C10: length 6.7
  TOP w0.254: R96.2 129,59.48 C109.1 128.44,59.52 126.22,57.31 U3.23
BMS2_C10_9: length 11.2
  TOP w0.254: U3.26 124.72,58.38 127.08,60.74 C110.1 127.12,61.13 C109.2 R97.2 129,62.7 C323.1
BMS2_C11: length 12.5
  TOP w0.254: C108.2 135.68,58.97 R95.2 132.16,58.97 131.23,58.04 127.8,58.04 126.72,56.95 U3.22
BMS2_C12: length 9.1
  TOP w0.254: C107.1 135.72,55.58 R93.2 133.39,53.97 131.44,52.03 U3.16
BMS2_C12_11: length 14.9
  TOP w0.254: C326.1 139.02,54.02 R94.2 C107.2 137.33,55.66 C108.1 133.99,57.37 130.15,53.53 U3.19
BMS2_C13: length 8.5
  TOP w0.254: U3.15 131.83,51.53 132.41,52.11 C106.2 135.84,52.07 R92.2
BMS2_C14: length 8.4
  TOP w0.254: U3.9 129.1,48.51 C105.1 135.77,46.91 R90.2
BMS2_C14_13: length 12.9
  TOP w0.254: U3.12 133.25,50.03 133.73,50.51 C106.1 137.37,48.95 C105.2 C320.1 139.02,48.46 R91.2
BMS2_C15: length 10.3
  TOP w0.254: U3.8 134.39,48.03 134.92,47.5 134.92,45.38 C104.2 135.34,44.96 R89.2
BMS2_C16: length 7.1
  TOP w0.254: R87.2 132.03,41.61 C103.1 132.08,43.22 130.28,45.03 U3.2
BMS2_C16_15: length 12.7
  TOP w0.254: C318.1 135.39,40.05 R88.2 ; C318.1 C103.2 ; C318.1 135.39,43.31 C104.1 132.17,46.53 U3.5
BMS2_DRIVE: length 11.8
  TOP w0.254: v1(119.38,39.88) 119.72,40.22 U3.65 ; v1(118.75,33.91) R146.1 119.8,32.43 C162.1
  L6_SIGNAL w0.254: v1(119.38,39.88) 118.75,39.24 v1(118.75,33.91)
  vias: v1(118.75,32.51)
BMS2_GPIO7: length 55.6
  TOP w0.254: R149.1 98.61,15.07 C166.1 98.65,16.1 v1(98.68,16.13) ; v1(124.28,37.82) 124.22,37.88 124.22,41.72 124.22,41.72 U3.74
  L3_SIGNAL w0.254: v1(124.28,37.82) 124.33,37.77 124.33,37.67 124.38,37.62 124.38,36.83 124.13,36.58 99.48,36.58 96.98,34.07 96.98,17.83 v1(98.68,16.13)
BMS2_GPIO7_INPUT: length 144
  TOP w0.254: P6.1 98.55,8 96.74,9.82 C174.1 96.74,11.89 R157.2 R149.2 v1(99.78,11.98) ; R394.2 R393.1 214.56,13.4 v1(214.76,13.21)
  L6_SIGNAL w0.254: v1(99.78,11.98) 101.6,10.16 101.6,2.67 102.74,1.52 205.11,1.52 205.74,2.16 205.74,7.75 211.2,13.21 v1(214.76,13.21)
BMS2_GPIO8: length 59.5
  TOP w0.254: v1(93.37,16.43) C168.1 93.37,13.71 R151.1 ; U3.73 123.72,42.66 123.72,38.97 123.57,38.82 v1(123.57,38.07)
  L3_SIGNAL w0.254: v1(93.37,16.43) 93.37,17.17 91.82,18.72 91.82,34.67 94.87,37.72 123.32,37.72 123.57,37.97 v1(123.57,38.07)
BMS2_GPIO8_INPUT: length 307.7
  TOP w0.254: v1(94.23,12.83) 94.93,12.13 R159.2 R151.2 93.41,10.58 C176.1 96.01,7.9 96.01,6.7 ; v1(295.72,94.11) R389.2 R397.1
  BOTTOM w0.254: v1(94.23,12.83) 100.2,12.83 111.89,1.14 289.43,1.14 295.72,7.43 v1(295.72,94.11)
BMS2_GPIO9: length 61.9
  TOP w0.254: U3.72 123.23,42.64 123.23,39.62 122.94,39.33 v1(122.94,38.48) ; R153.1 91.63,15.07 C170.1 91.67,15.97 v1(92.46,16.76)
  L3_SIGNAL w0.254: v1(92.46,16.76) 91.9,16.76 89.07,19.59 89.07,33.15 94.15,38.23 122.68,38.23 v1(122.94,38.48)
BMS2_GPIO9_INPUT: length 165.7
  TOP w0.254: P6.5 93.47,7.13 C178.1 90.1,10.58 R161.2 R153.2 91.86,11.98 v1(92.58,12.7)
  L3_SIGNAL w0.254: v1(215.9,53.97) 215.65,53.72 215.65,36.83 215.01,36.19 207.14,36.19 205.87,34.92 164.34,34.92 152.53,23.11 123.57,23.11 110.62,10.16 95.12,10.16 v1(92.58,12.7)
  BOTTOM w0.254: v1(215.9,53.97) 216.54,54.61 R391.2 216.85,55.88 R390.1
BMS2_GPIO10: length 61
  TOP w0.254: R155.1 86.64,13.71 C172.1 86.64,17.01 v1(86.61,17.04) ; U3.71 122.72,40.25 122.3,39.84 v1(122.3,39.12)
  L3_SIGNAL w0.254: v1(122.3,39.12) 122.05,38.86 92.88,38.86 86.61,32.6 v1(86.61,17.04)
BMS2_GPIO10_INPUT: length 159.9
  TOP w0.254: R163.2 88.9,12.68 v1(88.9,12.83) ; R163.2 R155.2 ; R163.2 88.2,10.59 C180.1 88.24,9.04 90.58,6.7 90.93,6.7
  L3_SIGNAL w0.254: v1(222.25,34.29) 221.83,33.87 216.5,33.87 214,31.37 180.85,31.37 177.93,34.29 164.72,34.29 153.04,22.61 123.95,22.61 110.87,9.52 94.49,9.52 91.31,12.7 89.03,12.7 v1(88.9,12.83)
  BOTTOM w0.254: v1(222.25,34.29) 222.31,34.35 R395.1 R396.2
BMS2_I2C_SCL: length 19.3
  TOP w0.254: U3.76 125.22,38.97 126.82,37.36 v1(128.5,37.36) ; U4.6 134.96,32.77 R145.2 133.49,32.35 v1(133.48,32.33)
  L6_SIGNAL w0.254: v1(128.5,37.36) 129.67,36.19 130.3,36.19 133.48,33.02 v1(133.48,32.33)
BMS2_I2C_SDA: length 17.8
  TOP w0.254: v1(128.45,38.13) 126.92,38.13 125.72,39.33 U3.77 ; 137.46,34.04 135,34.04 134.71,34.33 R147.2 v1(133.48,34.33)
  L6_SIGNAL w0.254: v1(133.48,34.33) 133.48,35.18 130.53,38.13 v1(128.45,38.13)
BMS2_IMA: length 14.9
  TOP w0.254: U3.58 109.91,45.53 C182.2 104.51,38.89 R164.1
BMS2_IMB: length 8
  TOP w0.254: R165.1 112.99,40.1 C183.2 114.42,41.53 117.83,41.53 118.22,41.92 U3.62
BMS2_IPA: length 12.8
  TOP w0.254: U3.59 110.56,45.03 107.45,41.92 C184.2 107.45,38.89 R166.1
BMS2_IPB: length 6.3
  TOP w0.254: U3.63 118.72,41.38 118.36,41.02 116.09,41.02 115.83,40.77 C336.2 115.83,38.89 R167.1
BMS2_NTC1: length 18.7
  TOP w0.254: v1(128.31,43.05) 127.92,42.66 U3.80
  L3_SIGNAL w0.254: v1(128.31,43.05) 128.31,41.78 129.2,40.89 134.11,40.89 137.54,37.46 v1(139.87,37.46)
  BOTTOM w0.254: R148.1 140.42,34.92 C165.1 140.42,36.92 v1(139.87,37.46)
BMS2_NTC2: length 14.2
  TOP w0.254: U3.79 126.72,40.33 128.06,38.99 133.14,38.99 v1(134.79,37.34)
  BOTTOM w0.254: R150.1 134.66,36.28 C167.1 134.62,37.17 v1(134.79,37.34)
BMS2_NTC3: length 12.3
  TOP w0.254: v1(126.57,39.45) 126.22,39.79 U3.78
  BOTTOM w0.254: R152.1 132.45,36.23 C169.1 132.36,37.05 130.58,38.84 127.18,38.84 v1(126.57,39.45)
BMS2_NTC4: length 9
  TOP w0.254: v1(125.25,37.72) 125.25,37.82 124.72,38.35 U3.75
  BOTTOM w0.254: R154.1 123.78,34.92 C171.1 123.78,36.96 124.03,37.21 124.74,37.21 v1(125.25,37.72)
BMS2_S1N: length 50.1
  TOP w0.254: v1(110.45,47.18) 110.6,47.03 U3.55
  TOP w0.381: v1(95.06,22.99) 95.06,20.63 96.65,19.05 R142.2 101.35,22.95 101.35,31.11 101.85,31.62 101.85,40.13 103.42,41.7 C142.2 103.46,44.32 v1(104.69,44.32)
  L3_SIGNAL w0.381: v1(110.45,47.18) 110.6,47.18 111.15,46.62 111.15,45.07 110.4,44.32 v1(104.69,44.32)
  BOTTOM w0.381: D52.2 v1(95.06,22.99)
BMS2_S1P: length 50.5
  TOP w0.254: v1(110.02,46.61) 110.11,46.53 U3.56
  TOP w0.381: v1(104.78,45.89) C142.1 102.87,45.89 102.49,45.5 102.49,41.78 101.27,40.56 101.27,31.87 100.58,31.18 100.58,26.19 v1(99.67,25.27) 99.67,24.36 98.93,23.62 R141.2
  L3_SIGNAL w0.381: v1(110.02,46.61) 109.3,45.89 v1(104.78,45.89)
  BOTTOM w0.381: C157.2 98.86,28.02 99.67,27.2 v1(99.67,25.27) 99.31,24.92 C158.1 97.31,24.91 D52.1 ; v1(104.78,45.89) C142.1
BMS2_S2N: length 40.5
  TOP w0.254: U3.52 112.08,48.53 v1(111.83,48.78)
  TOP w0.381: v1(104.94,47.88) 103.46,47.88 C141.2 102.2,47.84 101.8,47.45 101.8,42.11 100.69,41 100.69,32.74 99.82,31.88 99.82,30.61 97.45,28.23 R140.2 97.1,27.72 v1(95.12,27.72)
  L3_SIGNAL w0.381: v1(111.83,48.78) 111.83,48.75 111.99,48.59 111.99,47.83 111.65,47.5 111.17,47.5 110.79,47.88 v1(104.94,47.88)
  BOTTOM w0.381: D55.2 v1(95.12,27.72)
BMS2_S2P: length 48.5
  TOP w0.254: v1(111.17,48.51) 111.65,48.03 U3.53
  TOP w0.381: v1(104.56,49.4) 103.46,49.4 C141.1 102.53,49.44 101.22,48.13 101.22,42.54 100.1,41.43 100.1,34.57 v1(99.69,34.16) 99.69,32.89 99.31,32.51 R139.2
  L3_SIGNAL w0.381: v1(104.56,49.4) 104.94,49.02 110.66,49.02 v1(111.17,48.51)
  BOTTOM w0.381: v1(104.56,49.4) 103.46,49.4 C141.1 ; D55.1 97.3,29.63 C157.1 99.69,31.99 v1(99.69,34.16) 99.69,35.94 98.85,36.78 C156.2
BMS2_S3N: length 38.4
  TOP w0.254: v1(112.31,51.18) 112.56,51.18 113.22,50.53 U3.48
  TOP w0.381: v1(104.44,51.52) C140.2 102.32,51.52 100.63,49.83 100.63,43.23 99.52,42.11 99.52,39.03 R138.2 96.95,36.46 v1(95.17,36.46)
  L3_SIGNAL w0.381: v1(112.31,51.18) 113.07,51.18 113.63,50.62 113.63,50.09 113.2,49.66 106.85,49.66 104.98,51.52 v1(104.44,51.52)
  BOTTOM w0.381: D58.2 v1(95.17,36.46)
BMS2_S3P: length 42.8
  TOP w0.254: U3.49 112.84,50.03 112.58,50.29 112.56,50.29 v1(112.44,50.42)
  TOP w0.381: v1(104.27,53.12) C140.1 102.45,53.12 100.05,50.72 100.05,44.17 v1(99.44,43.56) 99.44,43.4 R137.2
  L3_SIGNAL w0.381: v1(112.44,50.42) 107.48,50.42 104.78,53.12 v1(104.27,53.12)
  BOTTOM w0.381: D58.1 97.31,38.37 C156.1 99.44,40.5 v1(99.44,43.56) 99.44,45.04 98.68,45.8 C155.2 ; v1(104.27,53.12) 104.14,53 C332.1
BMS2_S4N: length 31.6
  TOP w0.254: v1(110.53,55.63) 114.13,52.03 U3.45
  TOP w0.381: v1(95.17,45.5) 95.65,45.97 R136.2 99.47,47.99 99.47,51.31 100.97,52.81 100.97,55.37 102.07,56.48 C139.2 v1(104.35,56.48)
  L3_SIGNAL w0.381: v1(110.53,55.63) 109.68,56.48 v1(104.35,56.48)
  BOTTOM w0.381: D54.2 v1(95.17,45.5)
BMS2_S4P: length 44.5
  TOP w0.254: v1(110.66,54.61) 113.74,51.53 U3.46
  TOP w0.381: R135.2 99.69,52.67 v1(99.69,52.96) 99.69,55.75 101.98,58.04 103.25,58.04 C139.1 103.46,57.91 v1(104.31,57.91)
  L3_SIGNAL w0.381: v1(110.66,54.61) 111.42,55.37 111.42,57.53 111.04,57.91 v1(104.31,57.91)
  BOTTOM w0.381: C154.2 97.96,54.69 v1(99.69,52.96) 99.99,52.66 99.99,47.67 99.72,47.4 C155.1 97.3,47.41 D54.1 ; C337.1 103.33,57.91 v1(104.31,57.91)
BMS2_S5N: length 28.3
  TOP w0.254: U3.41 115.31,54.03 v1(114.21,55.12)
  TOP w0.381: v1(95.22,54.39) 95.82,54.99 R134.2 97.45,55.16 102.32,60.03 C138.2 105.24,60.07 v1(106.47,60.07)
  L3_SIGNAL w0.381: v1(114.21,55.12) 113.95,54.85 112.93,54.85 112.55,55.23 112.55,57.54 110.02,60.07 v1(106.47,60.07)
  BOTTOM w0.381: D51.2 v1(95.22,54.39)
BMS2_S5P: length 38.6
  TOP w0.254: v1(113.45,55.63) 113.45,55 114.93,53.53 U3.42
  TOP w0.381: v1(106.47,61.59) 106.43,61.63 C138.1 105.16,61.59 101.85,61.59 v1(99.82,59.56) R133.2
  L3_SIGNAL w0.381: v1(106.47,61.59) 109.77,61.59 113.45,57.91 v1(113.45,55.63)
  BOTTOM w0.381: D51.1 97.31,56.3 C154.1 99.82,58.79 v1(99.82,59.56) 99.82,61.85 97.84,63.84 C153.2 ; C138.1 105.24,61.59 v1(106.47,61.59)
BMS2_S6N: length 28.8
  TOP w0.254: v1(114.72,57.91) 117.76,57.91 118.72,56.95 U3.38
  TOP w0.381: v1(95.32,63.53) 97.1,63.53 R132.2 103,64.01 103.76,63.25 105.11,63.25 C137.2 v1(106.3,63.33)
  L3_SIGNAL w0.381: v1(114.72,57.91) 109.3,63.33 v1(106.3,63.33)
  BOTTOM w0.381: D57.2 v1(95.32,63.53)
BMS2_S6P: length 40.2
  TOP w0.254: v1(115.48,57.28) 117.64,57.28 118.22,56.7 U3.39
  TOP w0.381: v1(106.21,64.9) 105.24,64.9 C137.1 101.18,64.94 v1(98.17,67.94) R131.2
  L3_SIGNAL w0.381: v1(106.21,64.9) 108.88,64.9 115.48,58.29 v1(115.48,57.28)
  BOTTOM w0.381: D57.1 97.43,65.45 C153.1 97.45,67.22 v1(98.17,67.94) 101.05,70.83 C152.2 ; v1(106.21,64.9) 105.24,64.9 C137.1
BMS2_S7N: length 30
  TOP w0.254: U3.34 120.72,58.09 v1(118.55,60.26)
  TOP w0.381: v1(101.38,72.42) 102.62,71.19 R130.2 102.62,68.88 104.44,67.06 C136.2 107.36,65.83 v1(107.36,65.79)
  L6_SIGNAL w0.381: v1(118.55,60.26) 112.88,60.26 v1(107.36,65.79)
  BOTTOM w0.381: D56.2 v1(101.38,72.42)
BMS2_S7P: length 38.6
  TOP w0.254: U3.35 120.22,57.75 v1(118.66,59.31)
  TOP w0.381: R129.2 107.06,68.83 v1(107.7,68.2) 107.73,68.16 C136.1 109,65.79 v1(109.01,65.79)
  L6_SIGNAL w0.381: v1(118.66,59.31) 119,59.31 119.38,59.69 119.38,60.71 117.48,62.61 112.18,62.61 v1(109.01,65.79)
  BOTTOM w0.381: v1(109.01,65.79) 107.74,67.06 C136.1 ; D56.1 103.29,70.84 C152.1 105.91,68.2 v1(107.7,68.2) 109.35,68.2 110.7,69.55 C151.2
BMS2_S8N: length 24.7
  TOP w0.254: U3.31 122.22,59.18 121.82,59.58 v1(120.93,59.58)
  TOP w0.381: v1(112.78,65.91) 112.78,66.89 C135.2 111.51,68.16 R128.2 111.51,71.37 v1(110.37,72.51)
  L6_SIGNAL w0.381: v1(112.78,65.91) 112.95,65.91 114.48,64.39 117.02,64.39 120.93,60.47 v1(120.93,59.58)
  BOTTOM w0.381: D53.2 v1(110.37,72.51)
BMS2_S8P: length 36.3
  TOP w0.254: U3.32 121.72,58.66 v1(121.45,58.93)
  TOP w0.381: v1(114.34,66.08) 114.08,66.34 C135.1 115.06,67.18 v1(115.95,68.07) R127.2
  L6_SIGNAL w0.381: v1(121.45,58.93) 122.05,59.52 122.05,61.09 117.06,66.08 v1(114.34,66.08)
  BOTTOM w0.381: C329.1 114.05,66.37 v1(114.34,66.08) ; C150.2 119.59,69.3 118.36,68.07 v1(115.95,68.07) 113.16,68.07 112.3,68.93 C151.1 112.29,70.84 D53.1
BMS2_S9N: length 21.9
  TOP w0.254: v1(124.76,59.31) 124.7,59.31 124.22,58.82 U3.27
  TOP w0.381: v1(124.34,65.37) 124.34,66.89 C118.2 122.94,66.93 120.4,69.47 R114.2 120.4,71.19 v1(119.26,72.32)
  L6_SIGNAL w0.381: v1(124.34,65.37) 123.57,64.6 123.57,60.1 124.36,59.31 v1(124.76,59.31)
  BOTTOM w0.381: D42.2 v1(119.26,72.32)
BMS2_S9P: length 32
  TOP w0.254: v1(124.63,60.07) 123.72,59.16 U3.28
  TOP w0.381: R113.2 124.84,68.83 v1(125.86,67.82) 125.9,67.78 C118.1 125.77,66.81 v1(125.77,65.4)
  L6_SIGNAL w0.381: v1(124.63,60.07) 124.63,64.26 v1(125.77,65.4)
  BOTTOM w0.381: C149.2 128.36,68.2 127.97,67.82 v1(125.86,67.82) 122.68,67.82 121.19,69.31 C150.1 121.18,70.72 D42.1 ; v1(125.77,65.4) 125.9,65.53 C118.1
BMS2_S10N: length 23.9
  TOP w0.254: U3.24 125.72,57.63 v1(127.92,59.83)
  TOP w0.381: v1(128.05,72.36) 128.05,71.43 R112.2 132.97,66.51 C117.2 133.01,64.1 v1(133.01,62.99)
  L6_SIGNAL w0.381: v1(133.01,62.99) 129.85,59.83 v1(127.92,59.83)
  BOTTOM w0.381: D43.2 v1(128.05,72.36)
BMS2_S10P: length 35.6
  TOP w0.254: v1(126.91,59.69) 125.22,58 U3.25
  TOP w0.381: v1(134.57,63.08) C117.1 134.57,66.68 133.72,67.52 133.72,68.06 v1(133.73,68.07) R111.2
  L6_SIGNAL w0.381: v1(126.91,59.69) 127.55,59.06 130.85,59.06 134.57,62.78 v1(134.57,63.08)
  BOTTOM w0.381: v1(134.57,63.08) 134.57,64.07 C322.1 ; C148.2 137.5,70.7 134.87,68.07 v1(133.73,68.07) 132.59,68.07 C149.1 129.96,70.71 D43.1
BMS2_S11N: length 27.4
  TOP w0.254: U3.20 129.09,54.75 v1(129.58,55.24)
  TOP w0.381: v1(137.19,72.58) 138.3,71.47 R110.2 138.3,65.53 C116.2 v1(136.91,63.12)
  L6_SIGNAL w0.381: v1(129.58,55.24) 128.77,56.06 128.77,57.66 129.41,58.29 134.28,58.29 136.88,60.9 136.88,63.09 v1(136.91,63.12)
  BOTTOM w0.381: D44.2 v1(137.19,72.58)
BMS2_S11P: length 39.3
  TOP w0.254: U3.21 127.22,56.69 127.8,57.28 v1(129.58,57.28)
  TOP w0.381: R109.2 v1(142.75,68.07) 142.75,67.44 139.45,64.13 C116.1 138.47,64.1 v1(138.47,63.12)
  L6_SIGNAL w0.381: v1(138.47,63.12) 138.47,61.09 134.66,57.28 v1(129.58,57.28)
  BOTTOM w0.381: C147.2 146.52,69.81 144.78,68.07 v1(142.75,68.07) 141.9,68.07 C148.1 139.11,70.87 D44.1 ; v1(138.47,63.12) 138.47,64.1 C116.1
BMS2_S12N: length 35.9
  TOP w0.254: U3.17 131.05,52.53 132.38,53.85 v1(132.38,53.97)
  TOP w0.381: C115.2 v1(142.92,56.77) 142.92,65.79 R108.2 147.32,71.49 v1(146.18,72.63)
  L3_SIGNAL w0.381: v1(142.92,56.77) 140.12,53.97 v1(132.38,53.97)
  BOTTOM w0.381: D45.2 v1(146.18,72.63)
BMS2_S12P: length 44.9
  TOP w0.254: U3.18 130.66,53.03 v1(131.23,53.59)
  TOP w0.381: v1(141.9,54.1) 142.88,54.1 C115.1 142.96,54.1 143.64,54.1 144.02,54.48 144.02,63.25 v1(146.05,65.28) R107.2
  L3_SIGNAL w0.381: v1(141.9,54.1) 140.88,53.09 131.74,53.09 v1(131.23,53.59)
  BOTTOM w0.381: D45.1 148.1,70.76 C147.1 148.12,69.89 146.05,67.82 v1(146.05,65.28) 146.05,62.52 C146.2 ; v1(141.9,54.1) 142.88,54.1 C115.1
BMS2_S13N: length 30.4
  TOP w0.254: U3.13 132.86,50.53 v1(133.26,50.93)
  TOP w0.381: v1(150.49,61.18) 148.39,61.18 R106.2 146.43,60.83 144.91,59.31 144.91,53.97 142.88,51.94 141.81,51.94 C114.2 v1(140.42,51.98)
  L3_SIGNAL w0.381: v1(133.26,50.93) 133.26,51.6 133.76,52.1 138.51,52.1 138.62,51.98 v1(140.42,51.98)
  BOTTOM w0.381: D46.2 v1(150.49,61.18)
BMS2_S13P: length 37.3
  TOP w0.254: U3.14 132.22,51.03 132.71,51.51 133.95,51.51 v1(134.03,51.43)
  TOP w0.381: R105.2 v1(146.05,56.39) 145.49,55.83 145.49,53.16 142.71,50.38 C114.1 140.54,50.38 v1(140.5,50.42)
  L3_SIGNAL w0.381: v1(140.5,50.42) 138.61,50.42 137.59,51.43 v1(134.03,51.43)
  BOTTOM w0.381: C145.2 146.05,53.63 v1(146.05,56.39) 147.7,58.04 C146.1 147.71,59.27 D46.1 ; C114.1 140.54,50.38 v1(140.5,50.42)
BMS2_S14N: length 24.8
  TOP w0.254: v1(134.79,49.4) 134.41,49.03 U3.10
  TOP w0.381: v1(141.61,48.01) 141.99,48.39 143.26,48.39 C113.2 146.82,51.94 R104.2 149.83,51.94 v1(150.18,52.29)
  L3_SIGNAL w0.381: v1(134.79,49.4) 140.21,49.4 v1(141.61,48.01)
  BOTTOM w0.381: D47.2 v1(150.18,52.29)
BMS2_S14P: length 34.9
  TOP w0.254: v1(133.9,49.66) 133.77,49.53 U3.11
  TOP w0.381: v1(141.73,46.86) 143.26,46.86 C113.1 143.72,47.24 v1(145.92,47.24) R103.2
  L3_SIGNAL w0.381: v1(141.73,46.86) 140.84,46.86 139.45,48.26 134.53,48.26 133.9,48.89 v1(133.9,49.66)
  BOTTOM w0.381: C144.2 147.15,43.09 145.92,44.32 v1(145.92,47.24) 145.92,49.4 146.9,50.38 C145.1 147.71,50.38 D47.1 ; C328.1 142.58,46.86 v1(141.73,46.86)
BMS2_S15N: length 24.8
  TOP w0.254: U3.6 132.72,47.03 133.39,46.35 v1(134.03,46.35)
  TOP w0.381: v1(150.3,43.4) 149.7,42.8 R102.2 146.43,42.8 144.49,44.74 C112.2 140.55,44.74 v1(140.12,44.31)
  L3_SIGNAL w0.381: v1(134.03,46.35) 136.19,44.2 140.01,44.2 v1(140.12,44.31)
  BOTTOM w0.381: D48.2 v1(150.3,43.4)
BMS2_S15P: length 40
  TOP w0.254: v1(133.39,47.37) 133.24,47.53 U3.7
  TOP w0.381: R101.2 v1(145.67,38.23) 144.91,38.23 141.39,41.74 C112.1 141.35,43.18 v1(140.38,43.18)
  L3_SIGNAL w0.381: v1(133.39,47.37) 133.01,46.99 133.01,45.59 135.42,43.18 v1(140.38,43.18)
  BOTTOM w0.381: C112.1 140.42,43.14 v1(140.38,43.18) ; C143.2 146.65,33.82 145.67,34.8 v1(145.67,38.23) 145.67,39.59 C144.1 147.58,41.49 D48.1
BMS2_S16N: length 27.5
  TOP w0.254: U3.3 130.54,45.53 131.87,44.2 v1(133.01,44.2)
  TOP w0.381: v1(138.26,41.69) C111.2 140,41.69 R100.2 149.9,33.65 v1(150.4,34.16)
  L3_SIGNAL w0.381: v1(133.01,44.2) 135.51,41.69 v1(138.26,41.69)
  BOTTOM w0.381: D49.2 v1(150.4,34.16)
BMS2_S16P: length 35.8
  TOP w0.254: U3.4 131.31,46.03 v1(132.25,45.08)
  TOP w0.381: v1(138.22,40.13) 139.32,40.13 C111.1 145.33,34.13 v1(145.33,32.22) 145.33,30.95 147.19,29.08 R99.2
  L3_SIGNAL w0.381: v1(132.25,45.08) 132.25,43.81 135.93,40.13 v1(138.22,40.13)
  BOTTOM w0.381: v1(138.22,40.13) 138.26,40.09 C111.1 ; v1(145.33,32.22) C143.1 147.72,32.24 D49.1
BMS2_V-: length 21
  TOP w0.203: 5.88,89.24 5.45,89.24 5.31,89.38 5.21,89.38 v1(5.05,89.53) ; 5.88,89.24 5.77,89.13 v1(5.66,89.13) ; 5.88,89.24 R339.2
  TOP w0.508: R340.2 R342.2 ; R340.2 D23.C ; R340.2 R341.2 ; v1(47.65,41) 47.65,40.69 v1(48.08,40.26) 48.34,40 C67.2
  TOP w0.635: TP1.1 R339.2 6.82,89.15 8.13,89.15
  TOP w1.016: P1.18 P1.19 8.13,89.15
  vias: v1(5.05,90.25) v1(5.66,89.84)
BMS2_VREF2: length 13.1
  TOP w0.254: U3.68 121.22,41.82 120.73,41.33 120.73,40.36 120.95,40.14 v1(120.95,39.45)
  TOP w0.508: C160.1 v1(120.95,39.45)
  BOTTOM w0.508: E5.1 121.39,33.26 120.57,34.08 120.57,39.07 v1(120.95,39.45)
  vias: v1(103,18.67) v1(103,17.91)
BMS2_VREG: length 13.7
  TOP w0.203: v1(101.73,21.08) 101.94,20.87 R338.1
  TOP w0.254: U3.69 121.72,40.95 v1(121.41,40.64) ; v1(114.47,43.56) 114.47,44.2 114.8,44.53 U3.60
  TOP w0.508: v1(133.18,30.65) R145.1 134.96,30.23 U4.8 137.42,30.19 C163.1 ; R147.1 134.53,36.58 v1(133.65,37.46)
  vias: v1(102.36,21.08) v1(118.49,27.81) v1(118.49,27.18) v1(118.49,26.54) v1(118.49,25.91)
BMS3_1P25: length 30.8
  TOP w0.254: U5.15 180.69,20.04 v1(180.98,20.32)
  TOP w0.508: R183.2 R172.2 179.83,29.97 v1(179.81,30)
  BOTTOM w0.508: C195.1 179.96,21.97 180.98,20.95 v1(180.98,20.32) ; 150.5,24.76 150.62,24.89 153.67,24.89 ; 150.5,24.76 147.07,24.76 ; 150.5,24.76 R266.1 ; R265.1 v1(200.66,27.53) ; R250.1 153.92,24.64 153.67,24.89 ; R233.1 v1(207.39,27.56) ; 153.67,24.89 156.85,24.89 157.35,24.38 R234.1 157.39,24 v1(158.62,24) ; R298.1 143.76,24.26 144.27,24.76 147.07,24.76 ; 147.07,24.76 R282.1 ; R297.1 v1(193.93,27.56) ; R249.1 v1(203.96,27.53) ; R281.1 v1(197.23,27.56)
BMS3_GPIO1: length 26.9
  TOP w0.203: U5.28 171.81,16.62 v1(171.58,16.38)
  BOTTOM w0.203: P9.1 186.94,7.87 184.61,7.87 179.86,12.62 176.15,12.62 175.95,12.83 175.95,14.66 174.22,16.38 v1(171.58,16.38)
BMS3_GPIO2: length 26.3
  TOP w0.203: U5.29 172.1,16.12 171.81,15.82 171.35,15.82 v1(170.86,16.31)
  BOTTOM w0.203: v1(170.86,16.31) 170.86,16.03 171.12,15.77 174.12,15.77 175.49,14.4 175.49,12.37 175.69,12.17 179.65,12.17 184.58,7.24 185.04,7.24 P9.3
BMS3_GPO4: length 19.6
  TOP w0.203: v1(171.53,11.76) 171.73,11.96 173.89,11.96 175.04,13.12 U5.35
  BOTTOM w0.203: P9.5 183.77,5.84 178.26,11.35 174.83,11.35 174.22,11.96 171.73,11.96 v1(171.53,11.76)
BMS3_GPO5: length 9.4
  TOP w0.203: v1(175.64,10.41) 175.64,10.92 176.19,11.47 U5.37
  BOTTOM w0.203: v1(175.64,10.41) 178.05,8 179.2,8 P9.7
BMS3_GPO6: length 7.2
  TOP w0.203: P9.9 176.78,7.87 176.78,10.19 177.19,10.6 U5.39
BMS3_I2C_SCL: length 21.1
  TOP w0.254: R331.2 v1(168.73,13.46) ; R186.2 159.68,4.06 v1(159.13,4.06) U7.6
  L6_SIGNAL w0.254: v1(159.13,4.06) 159.31,4.06 161.16,5.92 161.16,10.54 163.75,13.13 168.4,13.13 v1(168.73,13.46)
BMS3_I2C_SDA: length 23
  TOP w0.254: R188.2 160.06,2.79 159.36,2.79 v1(159.23,2.92) 159.11,2.79 U7.5 ; R330.2 170.05,14.99 v1(169.67,14.6)
  L6_SIGNAL w0.254: v1(169.67,14.6) 169.67,13.41 168.78,12.52 163.91,12.52 161.8,10.41 161.8,5.33 159.39,2.92 v1(159.23,2.92)
BMS3_IMA: length 7.7
  TOP w0.203: U5.27 170,17.12 C205.1 169.41,16.53 R191.1
BMS3_IMA_ISO: length 23.3
  TOP w0.203: T5.8 182.4,35.25
  TOP w0.254: v1(165.23,38.73) T3.3 ; v1(182.37,33.15) 182.37,35.22 182.4,35.25
  L6_SIGNAL w0.254: v1(182.37,33.15) 182.25,33.02 179.58,33.02 177.93,34.67 170.31,34.67 166.24,38.73 v1(165.23,38.73)
BMS3_IMB: length 9.6
  TOP w0.203: U5.23 176.69,19.39 176.28,19.81 170.94,19.81 170.43,20.33 C206.1 170.39,21.37 R192.1
BMS3_IMB_ISO: length 72.1
  TOP w0.203: v1(104.05,20.32) T2.1
  TOP w0.254: T3.8 v1(158.88,38.73)
  L3_SIGNAL w0.254: v1(104.05,20.32) 105.71,18.67 116.26,18.67 123.32,25.73 152.6,25.73 156.46,29.59 156.46,38.23 156.97,38.73 v1(158.88,38.73)
BMS3_IPA: length 7.7
  TOP w0.203: R189.1 168.18,18.17 C203.1 169.97,17.62 U5.26
BMS3_IPA_ISO: length 18.9
  TOP w0.203: 179.86,35.25 T5.6
  TOP w0.254: v1(167.77,39.37) T3.1 ; v1(179.86,33.68) 179.86,35.25
  L6_SIGNAL w0.254: v1(179.86,33.68) 178.1,35.43 170.56,35.43 167.77,38.23 v1(167.77,39.37)
BMS3_IPB: length 6.9
  TOP w0.203: R190.1 173.27,21.24 C204.1 173.24,20.95 173.86,20.32 176.4,20.32 177.19,19.53 U5.22
BMS3_IPB_ISO: length 72.3
  TOP w0.203: 106.59,21.89 T2.3
  TOP w0.254: v1(106.59,20.11) 106.59,21.89 ; v1(161.42,38.73) T3.6
  L3_SIGNAL w0.254: v1(161.42,38.73) 160.78,39.37 156.21,39.37 155.83,38.99 155.83,29.72 152.55,26.44 122.86,26.44 115.98,19.56 107.14,19.56 v1(106.59,20.11)
BMS3_OCA: length 57.1
  TOP w0.203: U5.36 175.54,12.21 174.73,11.4 v1(172.54,11.4)
  TOP w0.254: U8.2 207.47,36.02 v1(207.9,35.59) 207.9,34.73 R197.2
  L6_SIGNAL w0.254: v1(207.9,35.59) 207.24,34.92 186.77,34.92 172.54,20.7 v1(172.54,11.4)
BMS3_OCB: length 65.8
  TOP w0.203: U5.38 176.69,10.96 176.2,10.46 176.2,10.18 175.8,9.78 v1(172.97,9.78)
  TOP w0.254: U8.3 208.74,36.42 v1(209.63,35.53) R198.2
  L6_SIGNAL w0.254: v1(172.97,9.78) 175.44,12.24 175.44,22.15 182.5,29.21 209.37,29.21 210.82,30.66 210.82,34.34 v1(209.63,35.53)
BMS3_V1: length 38.1
  TOP w0.203: U5.48 182.72,11.97 v1(183.39,11.3) 183.52,11.18 C258.1
  L3_SIGNAL w0.203: v1(183.39,11.3) 183.39,10.29 186.06,7.62 203.45,7.62 v1(207.06,11.23)
  BOTTOM w0.203: R247.2 207.52,11.68 v1(207.06,11.23)
BMS3_V2: length 33.6
  TOP w0.203: v1(184.53,11.94) 184.53,12.32 183.73,13.12 U5.2
  L3_SIGNAL w0.203: v1(184.53,11.94) 186.94,9.52 202.87,9.52 v1(203.43,10.08)
  BOTTOM w0.203: v1(203.43,10.08) 203.48,10.13 203.48,18.17 R263.2 ; C260.1 185.04,11.43 v1(184.53,11.94)
BMS3_V3: length 21.5
  TOP w0.203: v1(184.86,18.29) 183.69,17.12 U5.10
  L3_SIGNAL w0.203: v1(184.86,18.29) 185.5,18.92 195.61,18.92 196.69,17.84 200.63,17.84 v1(200.66,17.81)
  BOTTOM w0.203: v1(200.66,17.81) 200.66,18.65 R279.2 ; C262.1 v1(184.86,18.29)
BMS3_V4: length 26.8
  TOP w0.203: C264.1 178.98,21.59 v1(178.82,21.59) 178.82,21.21 179.19,20.83 U5.18
  L3_SIGNAL w0.203: v1(198.17,18.66) 195.88,20.95 185.8,20.95 184.28,22.48 179.71,22.48 v1(178.82,21.59)
  BOTTOM w0.203: v1(198.17,18.66) R295.2
BMS3_V5: length 14.8
  TOP w0.254: v1(185.09,15.62) 184.59,15.12 U5.6
  L3_SIGNAL w0.203: v1(185.09,15.62) 187.01,17.54 v1(193.94,17.54)
  BOTTOM w0.203: R311.2 v1(193.94,17.54)
  BOTTOM w0.254: C266.1 v1(185.09,15.62)
BMS3_V6: length 36.5
  TOP w0.203: C259.1 183.39,22 182.96,21.57 182.96,21.54 v1(182.63,21.21) 180.88,21.21 180.19,20.53 U5.16
  L3_SIGNAL w0.203: v1(157.24,14.91) 164.77,14.91 167.36,17.5 174.47,17.5 175.39,18.41 181.86,18.41 182.63,19.18 v1(182.63,21.21)
  BOTTOM w0.203: R248.2 v1(157.24,14.91)
BMS3_V7: length 39.3
  TOP w0.203: R173.2 182.12,25.78 182.5,25.4 182.5,22.86 182.21,22.57 C261.1 181.57,22.57 179.96,20.95 v1(179.83,20.95) 179.71,20.83 179.71,18.74 U5.17
  L3_SIGNAL w0.203: v1(153.94,14.87) 153.94,15.56 157.89,19.51 173.56,19.51 173.57,19.51 178.39,19.51 v1(179.83,20.95)
  BOTTOM w0.203: R264.2 v1(153.94,14.87)
BMS3_V8: length 43.3
  TOP w0.203: U5.13 181.69,19.26 182.12,19.68 183.26,19.68 183.52,19.94 v1(183.52,21.34) 183.93,21.34 C263.1
  L3_SIGNAL w0.203: v1(150.51,14.77) 150.71,14.77 155.85,19.91 173.39,19.91 173.4,19.92 177.93,19.92 179.99,21.97 182.88,21.97 v1(183.52,21.34)
  BOTTOM w0.203: R280.2 v1(150.51,14.77)
BMS3_V9: length 43.2
  TOP w0.203: R181.1 176.57,25.61 177.42,24.76 177.42,23.58 C265.1 178.44,22.22 178.05,21.84 v1(178.05,21.21) 178.06,21.21 178.69,20.57 U5.19
  L3_SIGNAL w0.203: v1(178.05,21.21) 177.19,20.35 152.8,20.35 v1(147.08,14.62)
  BOTTOM w0.203: R296.2 v1(147.08,14.62)
BMS3_V10: length 41.8
  TOP w0.203: U5.20 178.19,20.19 177.17,21.22 v1(177.17,21.34) 177.17,21.93 C267.1
  L3_SIGNAL w0.203: v1(177.17,21.34) 176.66,20.83 149.15,20.83 143.78,15.46 v1(143.78,14.96)
  BOTTOM w0.203: R312.2 v1(143.78,14.96)
BMS3_VBAT1: length 1.5
  TOP w0.203: 212.47,21.08 212.47,20.83
  BOTTOM w0.508: v1(186.78,23.09) R184.1
  vias: v1(186.77,23.7) v1(210.44,22.22) v1(211.2,22.22) v1(212.22,22.22) v1(212.98,22.22)
BMS3_VREG: length 12.2
  TOP w0.254: v1(177.69,10.03) 177.69,10.67 ; 177.69,10.67 178.44,10.67 178.69,10.92 U5.42 ; 177.69,10.67 U5.40 ; U13.1 218.48,39.17 218.44,39.2
  TOP w0.279: v1(173.74,18.54) 174.16,18.12 U5.25
  TOP w0.762: R188.1 R186.1
  TOP w0.889: TP7.1 138.29,7.23 C202.1
  vias: v1(138.25,14.5) v1(138.25,13.79) v1(138.25,13.08) v1(139.12,14.5) v1(139.12,13.79) v1(139.12,13.13) v1(158.62,8.61) v1(158.62,7.95) v1(159.33,8.61) v1(159.33,7.95) v1(206.12,33.6) v1(206.12,32.99) v1(206.73,33.6) v1(206.73,32.99) v1(207.39,32.08) v1(208.15,32.08) v1(208.92,32.08) v1(209.68,32.08) v1(214.88,34.67) v1(214.88,34.04) v1(215.52,34.67) v1(215.52,34.04) v1(216.28,48.13) v1(216.28,47.5) v1(216.28,39.46) v1(216.28,38.82) v1(216.92,39.46) v1(216.92,38.82) v1(217.04,48.13) v1(217.04,47.5)
CHARGE_FET_INP: length 3.5
  TOP w0.254: v1(221.62,37.46) 221.48,37.6 U13.4 ; v1(173.81,14.6) 173.83,14.62 U5.32
DISCHARGE_FET_INP: length 4.1
  TOP w0.254: v1(173.61,13.72) 173.86,13.72 174.26,14.12 U5.33 ; U11.4 215.7,31.05 215.39,30.73 v1(214.76,30.73)
HYP_CLKN: length 10.2
  TOP w0.203: R374.1 v1(204.85,70.87)
  L6_SIGNAL w0.203: v1(204.85,70.87) 205.64,70.08 208.56,70.08 TP6.1
HYP_CLKP: length 11.2
  TOP w0.203: R373.1 204.85,72.39 205.31,72.85 205.31,78.03 204.34,78.99 TP5.1
I1A: length 11.5
  TOP w0.203: R327.2 191.05,9.98 190.84,9.78 187.2,9.78 186.91,10.07 C357.2
  TOP w0.254: C357.2 183.96,13.62 U5.3
I1AS: length 167.9
  TOP w0.381: R327.1 v1(193.68,10.67) ; R328.1 v1(193.68,14.48) 195.2,14.48 195.71,13.97 C351.1 195.73,12.89 L6.2 L6.1 203.99,12.89 C352.1 v1(204.18,14.05)
  L6_SIGNAL w0.381: R375.I1P 303.03,45.85 298.58,41.4 298.58,9.52 294.51,5.46 224.66,5.46 215.52,14.6 204.74,14.6 v1(204.18,14.05) ; v1(193.68,10.67) v1(193.68,14.48)
I1B: length 10.9
  TOP w0.203: R174.1 191.05,11.89 190.84,11.68 187.07,11.68 186.91,11.85 C343.2 185.36,14.12 U5.4
