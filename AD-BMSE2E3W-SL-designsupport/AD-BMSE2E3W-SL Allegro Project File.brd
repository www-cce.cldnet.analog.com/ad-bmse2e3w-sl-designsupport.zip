# Allegro board AD-BMSE2E3W-SL Allegro Project File.brd (continued)
## Library data of the parts (continued)
L3 = IND: User Part Number: UPN; Tolerance: 20; alternate symbols: (L0805); part number: IND_SM-4.7UH,20,E022483,L0805; tolerance: 20
L4-L6 = CHOKE4P: User Part Number: UPN; Tolerance: N/A; alternate symbols: (LSML177W126H114); part number: CHOKE4P_SM-200UH,N/A,E038585,LSML177W126H114; tolerance: N/A
P1 P4 = CN19P: User Part Number: UPN; Tolerance: N/A; alternate symbols: (CNTHMHDRRA1X19L2673W437H295); part number: CN19P_TH-1841800000,E048787,CNTHMHDRRA1X19L2673W437H295; tolerance: N/A
P2 P5 = CN8P_ODD_EVEN: Tolerance: N/A; User Part Number: UPN; alternate symbols: (CNMOLEX1053141308); part number: CN8P_ODD_EVEN_TH-1053141308,E048786,CNMOLEX1053141308; tolerance: N/A
P3 P6 = CN8P_A: Tolerance: N/A; User Part Number: UPN; alternate symbols: (CNTHMHDR2X4L400W200H330); part number: CN8P_A_TH-TSW-104-07-G-D,E042079,CNTHMHDR2X4L400W200H330; tolerance: N/A
P7-P9 = CN10P: User Part Number: UPN; Tolerance: N/A; alternate symbols: (CNSAMTEC2X5H338LD36); part number: CN10P_TH-TSW-105-08-G-D,E006587,CNSAMTEC2X5H338LD36; tolerance: N/A
P10 = CN3P: User Part Number: UPN; Tolerance: N/A; alternate symbols: (CNOSTTF030161); part number: CN3P_TH-OSTTF030161,E025859,CNOSTTF030161; tolerance: N/A
P11 = CN5P_6SHLD: Tolerance: N/A; User Part Number: UPN; alternate symbols: (CNHRSZX62-B-5PA_6SHLD); part number: CN5P_6SHLD_SM-ZX62-AB-5PA(31),E042196,CNHRSZX62-B-5PA_6SHLD; tolerance: N/A
P12 = CN10P_ODD_EVEN: User Part Number: UPN; Tolerance: N/A; alternate symbols: (CNSMMHDR2X5L443W201H228); part number: CN10P_ODD_EVEN_SM-3220-10-0300-00,E027502,CNSMMHDR2X5L443W201H228; tolerance: N/A
P13 P14 = CN12P: User Part Number: UPN; Tolerance: N/A; alternate symbols: (CNHDR1X12H420); part number: CN12P_TH-TSW-112-16-G-S,E024532,CNHDR1X12H420; tolerance: N/A
P15-P19 P21-P23 = CN2P: User Part Number: UPN; Tolerance: N/A; alternate symbols: (CNBERG69157-102); part number: CN2P_TH-69157-102HLF,E000791,CNBERG69157-102; tolerance: N/A
P20 = CN3P: Tolerance: N/A; User Part Number: UPN; alternate symbols: (CNHDR1X3H340); part number: CN3P_TH-M20-9990345,E017614,CNHDR1X3H340; tolerance: N/A
Q1 Q2 = TRANNPN_4P_V2: User Part Number: UPN; Tolerance: N/A; alternate symbols: (SOT223_A); part number: TRANNPN_4P_V2_SM-BCP56-16TF,E042244,SOT223_A; tolerance: N/A
Q3-Q15 = TRANNMOSFET_V10: User Part Number: UPN; Tolerance: N/A; alternate symbols: (TO263-3); part number: TRANNMOSFET_V10_SM-IPB048N15N5LFATMA1,E065713,TO263-3; tolerance: N/A
R1-R13 R30-R41 R87-R98 R115-R126 R341 = RES: User Part Number: UPN; Tolerance: 1; alternate symbols: (R0603); part number: RES_SM-200,E007248,1/10W,1,R0603; tolerance: 1
R14-R29 R42-R57 R99-R114 R127-R142 = RES: User Part Number: UPN; Tolerance: 1; alternate symbols: (R2512-2); part number: RES_SM-15,E041666,1.5W,1,R2512-2; tolerance: 1
R58 R63 R65 R67 R69 R143 R148 R150 R152 R154 R173 R181 R184 R185 R247 R248 R263 R264 R279 R280 R295 R296 R311 R312 R398 = RES: User Part Number: UPN; Tolerance: 1; alternate symbols: (R0603); part number: RES_SM-1K,E003678,1/10W,1,R0603; tolerance: 1
R59 R144 = RES: User Part Number: UPN; Tolerance: 1; alternate symbols: (R0603); part number: RES_SM-330,E054284,1/10W,1,R0603; tolerance: 1
R60 R62 R72 R74 R76 R78 R145 R147 R186 R188 = RES: User Part Number: UPN; Tolerance: 5; alternate symbols: (R0603); part number: RES_SM-3.3K,E036086,1/4W,5,R0603; tolerance: 5
R61 R146 = RES: User Part Number: UPN; Tolerance: 1; alternate symbols: (R0603); part number: RES_SM-10,E030868,1/10W,1,R0603; tolerance: 1
R64 R66 R68 R70 R149 R151 R153 R155 R182 R210-R213 R216-R220 R229 R231-R234 R240 R246 R249 R250 R256 R262 R265 R266 R272 R278 R281 R282 R288 R294 R297 R298 R304 R310 R314-R316 R320-R324 R330 R331 R337-R340 R342-R345 R350-R374 R376 R381 R382 R392 = RES: User Part Number: UPN; Tolerance: JUMPER; alternate symbols: (R0603); part number: RES_SM-0,E006826,1/10W,JUMPER,R0603; tolerance: JUMPER
R71 R73 R75 R77 R156-R163 R172 R183 R197-R200 R224 R225 R230 = RES: User Part Number: UPN; Tolerance: 1; alternate symbols: (R0603); part number: RES_SM-10K,E003671,1/10W,1,R0603; tolerance: 1
R79-R82 R164-R167 R189-R192 R204 R205 R208 R209 = RES: User Part Number: UPN; Tolerance: 1; alternate symbols: (R0603); part number: RES_SM-22,E042884,1/10W,1,R0603; tolerance: 1
R83-R86 R168-R171 R193-R196 R202 R203 R206 R207 = RES: User Part Number: UPN; Tolerance: 1; alternate symbols: (R0603); part number: RES_SM-51,E010181,1/10W,1,R0603; tolerance: 1
R174-R176 R325-R329 = RES: User Part Number: UPN; Tolerance: 1; alternate symbols: (R0603); part number: RES_SM-120,E010184,1/10W,1,R0603; tolerance: 1
R177-R179 R390 R394 R396 R397 = RES: User Part Number: UPN; Tolerance: 1; alternate symbols: (R0805); part number: RES_SM-1.24MEG,E049781,1/8W,1,R0805; tolerance: 1
R180 = RES: User Part Number: UPN; Tolerance: 1; alternate symbols: (R0805); part number: RES_SM-100K,E003488,1/8W,1,R0805; tolerance: 1
R187 = RES: User Part Number: UPN; Tolerance: 1; alternate symbols: (R0603); part number: RES_SM-2MEG,E034670,1/10W,1,R0603; tolerance: 1
R201 = RES: User Part Number: UPN; Tolerance: 1; alternate symbols: (R0603); part number: RES_SM-316K,E027926,1/10W,1,R0603; tolerance: 1
R214 R215 = RES: User Part Number: UPN; Tolerance: 1; alternate symbols: (R0603); part number: RES_SM-20K,E017927,1/10W,1,R0603; tolerance: 1
R221-R223 R226-R228 R380 R383-R388 = RES: User Part Number: UPN; Tolerance: 1; alternate symbols: (R0603); part number: RES_SM-10,E003666,1/10W,1,R0603; tolerance: 1
R235-R239 R241-R245 R251-R255 R257-R261 R267-R271 R273-R277 R283-R287 R289-R293 R299-R303 R305-R309 = RES: User Part Number: UPN; alternate symbols: (R0603); part number: RES_SM-TBD0603,E004050,TBD0603,TBD0603,R0603
R313 R317 R318 R346-R349 = RES: User Part Number: UPN; Tolerance: 1; alternate symbols: (R1206); part number: RES_SM-10K,E004075,1/4W,1,R1206; tolerance: 1
R319 = RES: User Part Number: UPN; Tolerance: 5; alternate symbols: (R0402); part number: RES_SM-120,E003453,1/10W,5,R0402; tolerance: 5
R332-R336 = RES: User Part Number: UPN; Tolerance: 1; alternate symbols: (R0603); part number: RES_SM-1.2K,E050671,1/10W,1,R0603; tolerance: 1
R375 = RES6PKEL_2GND: User Part Number: UPN; Tolerance: 5; alternate symbols: (RSML3307W787H124_6FS); part number: RES6PKEL_2GND_SM-0.0001,E058948,36W,5,RSML3307W787H124_6FS; tolerance: 5
R377-R379 = RES: Tolerance: 5; User Part Number: UPN; alternate symbols: (R5329); part number: RES_SM-33,E050292,5W,5,R5329; tolerance: 5
R389 R391 R393 R395 = RES: User Part Number: UPN; Tolerance: 0.1; alternate symbols: (R0805); part number: RES_SM-43K,E036026,1/8W,0.1,R0805; tolerance: 0.1
RT1 RT2 = RESTHERM: Tolerance: 1; User Part Number: UPN; alternate symbols: (R0603H35); part number: RESTHERM_SM-10K,E048374,100MW,1,R0603H35; tolerance: 1
S1 = SWSPST2PIN_V2: Tolerance: N/A; User Part Number: UPN; alternate symbols: (SWSML118W98H69); part number: SWSPST2PIN_V2_SM-B3U-1000P,E016303,SWSML118W98H69; tolerance: N/A
T1-T3 T5 = XFMR16P_V8: Tolerance: N/A; User Part Number: UPN; alternate symbols: (TSML510W280H215); part number: XFMR16P_V8_SM-7490100111,E066949,TSML510W280H215; tolerance: N/A
T4 = XFMR6P_V22: Tolerance: N/A; User Part Number: UPN; alternate symbols: (TSML400W295H340); part number: XFMR6P_V22_SM-750312367,E060475,TSML400W295H340; tolerance: N/A
TP1-TP4 TP7 TP8 = NCTESTPAD: Tolerance: N/A; User Part Number: UPN; alternate symbols: (TPC63D35); part number: NCTESTPAD_TH-TP_VIA,E012149,TPC63D35; tolerance: N/A
TP5 TP6 TP14 TP15 = NCTESTPAD: Tolerance: N/A; User Part Number: UPN; alternate symbols: (PAD160T100BR90); part number: NCTESTPAD_TH-TESTPAD,E007184,PAD160T100BR90; tolerance: N/A
TP9 TP11 TP13 = CNTP1P: User Part Number: UPN; Tolerance: N/A; alternate symbols: (CNMILLMAX2501); part number: CNTP1P_TH-2501-2-00-80-00-00-07-0,E031108,CNMILLMAX2501; tolerance: N/A
TP10 TP12 TP16 = CNTP1P: Tolerance: N/A; User Part Number: UPN; alternate symbols: (CNBANANAD312LD203); part number: CNTP1P_TH-575-4,E012555,CNBANANAD312LD203; tolerance: N/A
U1 U3 = ADBMS6830: Tolerance: N/A; User Part Number: UPN; alternate symbols: (QFP80_12X12_PAD5_81X5_81); part number: ADBMS6830_SM-ADBMS6830MWCSWZ,E066878,QFP80_12X12_PAD5_81X5_81; tolerance: N/A
U2 U4 U7 = IC24XX02: Tolerance: N/A; User Part Number: UPN; alternate symbols: (SO8); part number: IC24XX02_SM-24LC02B-E/SN,E027039,SO8; tolerance: N/A
U5 = ADBMS2950: Tolerance: N/A; User Part Number: UPN; alternate symbols: (QFN48_7X7_PAD4_8X4_8); part number: ADBMS2950_SM-ADBMS2950WCCSZ,E042351,QFN48_7X7_PAD4_8X4_8; tolerance: N/A
U6 = ADLTC3639: Tolerance: N/A; User Part Number: UPN; alternate symbols: (MSOP16_PAD2_845X1_651_12P); part number: ADLTC3639_SM-LTC3639EMSE#PBF,E048616,MSOP16_PAD2_845X1_651_12P; tolerance: N/A
U8 = ADUM225N: User Part Number: UPN; Tolerance: N/A; alternate symbols: (SO8WB_A); part number: ADUM225N_SM-ADUM225N1BRIZ,E034609,SO8WB_A; tolerance: N/A
U9 = ADLT8303: User Part Number: UPN; Tolerance: N/A; alternate symbols: (TSOT-5); part number: ADLT8303_SM-LT8303IS5#TRMPBF,E056562,TSOT-5; tolerance: N/A
U10 = ADBMS6822: User Part Number: UPN; Tolerance: N/A; alternate symbols: (QFN32_5X5_PAD2_1X2_1); part number: ADBMS6822_SM-ADBMS6822WCCSZ,E046212,QFN32_5X5_PAD2_1X2_1; tolerance: N/A
U11-U13 = ADLTC7001: User Part Number: UPN; Tolerance: N/A; alternate symbols: (MSOP10_PAD1_88X1_68); part number: ADLTC7001_SM-LTC7001IMSE#WPBF,E047833,MSOP10_PAD1_88X1_68; tolerance: N/A
U14 = ADMAX20337: User Part Number: UPN; Tolerance: N/A; alternate symbols: (DFN6_F61A1F_1); part number: ADMAX20337_SM-MAX20337AEFT+,E065680,DFN6_F61A1F_1; tolerance: N/A
U15 = ADMAX25301A: User Part Number: UPN; Tolerance: N/A; alternate symbols: (DFN10_3X3_PAD2_3X1_5); part number: ADMAX25301A_SM-MAX25301AATB/V+,E062177,DFN10_3X3_PAD2_3X1_5; tolerance: N/A
U16 = ADP151_V2: Tolerance: N/A; User Part Number: UPN; alternate symbols: (WLCSP4H26); part number: ADP151_V2_SM-ADP151ACBZ-1.8-R7,E021109,WLCSP4H26; tolerance: N/A
U17 = ADP151_V2: Tolerance: N/A; User Part Number: UPN; alternate symbols: (WLCSP4H26); part number: ADP151_V2_SM-ADP151WACBZ-1.2,E044726,WLCSP4H26; tolerance: N/A
U18 = ADP151_V2: Tolerance: N/A; User Part Number: UPN; alternate symbols: (WLCSP4H26); part number: ADP151_V2_SM-ADP151ACBZ-1.1,E055715,WLCSP4H26; tolerance: N/A
U19 = ADLTC2875: User Part Number: UPN; Tolerance: N/A; alternate symbols: (DFN8_3X3_PAD2_38X1_65); part number: ADLTC2875_SM-LTC2875HDD#PBF,E035076,DFN8_3X3_PAD2_38X1_65; tolerance: N/A
U20 = ICMAX6071: User Part Number: UPN; Tolerance: N/A; alternate symbols: (SOT23_6-3); part number: ICMAX6071_SM-MAX6071AAUT33+T,E062693,SOT23_6-3; tolerance: N/A
U21 = ADMAX3207E: User Part Number: UPN; Tolerance: N/A; alternate symbols: (SOT23_6); part number: ADMAX3207E_SM-MAX3207EAUT+,E059110,SOT23_6; tolerance: N/A
U22 = ADMAX32690_V2: User Part Number: UPN; Tolerance: N/A; alternate symbols: (QFN68_8X8_PAD6_25X6_25); part number: ADMAX32690_V2_SM-MAX32690GTK+,E063217,QFN68_8X8_PAD6_25X6_25; tolerance: N/A
Y1 = XTAL: User Part Number: UPN; Tolerance: 20PPM; alternate symbols: (YSML65W41H20); part number: XTAL_SM-32.768KHZ,E034955,YSML65W41H20; tolerance: 20PPM
Y2 = XTAL4PIN_V3: User Part Number: UPN; Tolerance: 10PPM; alternate symbols: (YSML63W47H14); part number: XTAL4PIN_V3_SM-32MHZ,E063124,YSML63W47H14; tolerance: 10PPM

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
C0402
  rect 0.584x0.66 smd: 1(-0.5,0) 2(0.5,0)
C0603
  rect 0.94x0.991 smd: 1(-0.8,0) 2(0.8,0)
C0805
  rect 1.143x1.448 smd: 1(-0.9,0) 2(0.9,0)
C0805H53
  rect 1.295x1.6 smd: 1(-0.953,0) 2(0.953,0)
C0805H55
  rect 1.143x1.448 smd: 1(-0.9,0) 2(0.9,0)
C1206
  rect 1.143x1.803 smd: 1(-1.5,0) 2(1.5,0)
C1206H71
  rect 1.6x2.007 smd: 1(-1.397,0) 2(1.397,0)
C1210H87
  rect 1.092x2.21 smd: 1(-1.646,0) 2(1.646,0)
C1210H110
  rect 1.372x2.794 smd: 1(-1.431,0) 2(1.431,0)
C1825H65
  rect 1.397x6.807 smd: 1(-2.05,0) 2(2.05,0)
C2220H98
  rect 1.549x5.41 smd: 1(-2.65,0) 2(2.65,0)
CNBANANAD312LD203
  round 9.144 hole 5.41: 1(0,0)
CNBERG69157-102
  rect 1.524x1.524 hole 1.016: 1(0,0)
  round 1.524 hole 1.016: 2(2.54,0)
CNHDR1X3H340
  rect 1.651x1.651 hole 1.143: 1(0,0)
  round 1.651 hole 1.143: 2(2.54,0) 3(5.08,0)
CNHDR1X12H420
  rect 1.651x1.651 hole 1.143: 1(0,0)
  round 1.651 hole 1.143: 2(2.54,0) 3(5.08,0) 4(7.62,0) 5(10.16,0) 6(12.7,0) 7(15.24,0) 8(17.78,0) 9(20.32,0) 10(22.86,0) 11(25.4,0) 12(27.94,0)
CNHRSZX62-B-5PA_6SHLD
  rect 0.406x1.346 smd: 1(-1.3,2.677) 2(-0.65,2.677) 3(0,2.677) 4(0.65,2.677) 5(1.3,2.677)
  rect 2.108x1.6 smd: SH1(-3.104,2.55) SH6(3.104,2.55)
  rect 1.803x1.905 smd: SH2(-4.002,0) SH5(4.002,0)
  rect 1.905x1.905 smd: SH3(-1.202,0) SH4(1.202,0)
CNMILLMAX2501
  round 3.048 hole 2.54: 1(0,0)
CNMOLEX1053141308
  oval 2.769x2.616 hole 1.753x1.6 unplated: (0,9.68)
  round 2.362 hole 1.6 unplated: (7.5,9.68)
  rect 1.778x1.778 hole 1.27: 1(0,0)
  round 1.778 hole 1.27: 2(0,2.5) 3(2.5,0) 4(2.5,2.5) 5(5,0) 6(5,2.5) 7(7.5,0) 8(7.5,2.5)
CNOSTTF030161
  rect 1.778x1.778 hole 1.27: 1(0,0)
  round 1.778 hole 1.27: 2(3.5,0) 3(7,0)
CNSAMTEC2X5H338LD36
  rect 1.651x1.651 hole 1.143: 1(0,0)
  round 1.651 hole 1.143: 2(0,2.54) 3(2.54,0) 4(2.54,2.54) 5(5.08,0) 6(5.08,2.54) 7(7.62,0) 8(7.62,2.54) 9(10.16,0) 10(10.16,2.54)
CNSMMHDR2X5L443W201H228
  rect 0.762x2.311 smd: 1(-2.54,-1.906) 2(-2.54,1.906) 3(-1.27,-1.906) 4(-1.27,1.906) 5(0,-1.906) 6(0,1.906) 7(1.27,-1.906) 8(1.27,1.906) 9(2.54,-1.906) 10(2.54,1.906)
CNTHMHDR2X4L400W200H330
  rect 1.651x1.651 hole 1.143: 1(0,0)
  round 1.651 hole 1.143: 2(0,2.54) 3(2.54,0) 4(2.54,2.54) 5(5.08,0) 6(5.08,2.54) 7(7.62,0) 8(7.62,2.54)
CNTHMHDRRA1X19L2673W437H295
  rect 1.905x1.905 hole 1.397: 1(0,0)
  round 1.905 hole 1.397: 2(3.5,0) 3(7,0) 4(10.5,0) 5(14,0) 6(17.5,0) 7(21,0) 8(24.5,0) 9(28,0) 10(31.5,0) 11(35,0) 12(38.5,0) 13(42,0) 14(45.5,0) 15(49,0) 16(52.5,0) 17(56,0) 18(59.5,0) 19(63,0)
CPLSMSQ327H413
  rect 4.191x2.057 smd: N(3.65,0) P(-3.65,0)
DFN6_F61A1F_1
  rect 0.711x0.279 smd: 1(-0.569,0.5) 2(-0.569,0) 3(-0.569,-0.5) 4(0.569,-0.5) 5(0.569,0) 6(0.569,0.5)
DFN8_3X3_PAD2_38X1_65
  oval 0.279x0.737 smd: 1(-0.75,-1.393) 2(-0.25,-1.393) 3(0.25,-1.393) 4(0.75,-1.393) 5(0.75,1.393) 6(0.25,1.393) 7(-0.25,1.393) 8(-0.75,1.393)
  rect 2.388x1.651 smd: PAD(0,0)
DFN10_3X3_PAD2_3X1_5
  oval 0.279x0.711 smd: 1(-1,-1.396) 2(-0.5,-1.396) 3(0,-1.396) 4(0.5,-1.396) 5(1,-1.396) 6(1,1.396) 7(0.5,1.396) 8(0,1.396) 9(-0.5,1.396) 10(-1,1.396)
  rect 2.311x1.499 smd: PAD(0,0)
DO214AA_A
  rect 2.261x2.159 smd: A(2.197,0) C(-2.197,0)
DO214AC_A
  rect 1.524x1.651 smd: A(1.88,0) C(-1.88,0)
DTH819L350W350LD52_BIDIR
  rect 2.159x2.159 hole 1.651: 1(0,0)
  round 2.159 hole 1.651: 2(20.803,0)
FSML484W177H185
  rect 4.699x5.791 smd: 1(-4.549,0) 2(4.549,0)
L0603
  rect 0.94x0.991 smd: 1(-0.8,0) 2(0.8,0)
L0805
  rect 1.194x1.448 smd: 1(-0.85,0) 2(0.85,0)
L1206
  rect 1.524x1.575 smd: 1(-1.714,0) 2(1.714,0)
L1206-3
  rect 1.6x1.803 smd: 1(-1.397,0) 2(1.397,0)
LED0603-2
  rect 0.787x0.787 smd: A(0.787,0) C(-0.787,0)
LSML177W126H114
  rect 1.194x0.711 smd: 1(-2.347,-0.7) 2(2.347,-0.7) 3(2.347,0.7) 4(-2.347,0.7)
LSML402W394H201
  rect 1.778x3.556 smd: 1(-4.7,0) 2(4.7,0)
MSOP10_PAD1_88X1_68
  rect 0.305x1.143 smd: 1(-1,-2.106) 2(-0.5,-2.106) 3(0,-2.106) 4(0.5,-2.106) 5(1,-2.106) 6(1,2.106) 7(0.5,2.106) 8(0,2.106) 9(-0.5,2.106) 10(-1,2.106)
  rect 1.88x1.676 smd: PAD(0,0)
MSOP16_PAD2_845X1_651_12P
  rect 0.305x1.448 smd: 1(-1.75,-2.15) 3(-0.75,-2.15) 5(0.25,-2.15) 6(0.75,-2.15) 7(1.25,-2.15) 8(1.75,-2.15) 9(1.75,2.15) 10(1.25,2.15) 11(0.75,2.15) 12(0.25,2.15) 14(-0.75,2.15) 16(-1.75,2.15)
  rect 2.845x1.651 smd: PAD(0,0)
PAD160T100BR90
  round 4.064 hole 2.286: 1(0,0)
QFN32_5X5_PAD2_1X2_1
  oval 0.279x0.737 smd: 1(-1.75,-2.383) 2(-1.25,-2.383) 3(-0.75,-2.383) 4(-0.25,-2.383) 5(0.25,-2.383) 6(0.75,-2.383) 7(1.25,-2.383) 8(1.75,-2.383) 17(1.75,2.383) 18(1.25,2.383) 19(0.75,2.383) 20(0.25,2.383) 21(-0.25,2.383) 22(-0.75,2.383) 23(-1.25,2.383) 24(-1.75,2.383)
  oval 0.737x0.279 smd: 9(2.383,-1.75) 10(2.383,-1.25) 11(2.383,-0.75) 12(2.383,-0.25) 13(2.383,0.25) 14(2.383,0.75) 15(2.383,1.25) 16(2.383,1.75) 25(-2.383,1.75) 26(-2.383,1.25) 27(-2.383,0.75) 28(-2.383,0.25) 29(-2.383,-0.25) 30(-2.383,-0.75) 31(-2.383,-1.25) 32(-2.383,-1.75)
  rect 2.108x2.108 smd: PAD(0,0)
QFN48_7X7_PAD4_8X4_8
  custom 0.064x0.064 smd: 1(-2.75,-3.394) 12(2.75,-3.394) 13(3.394,-2.75) 24(3.394,2.75) 25(2.75,3.394) 36(-2.75,3.407) 37(-3.394,2.75) 48(-3.394,-2.75)
  rect 0.254x0.787 smd: 2(-2.25,-3.356) 3(-1.75,-3.356) 4(-1.25,-3.356) 5(-0.75,-3.356) 6(-0.25,-3.356) 7(0.25,-3.356) 8(0.75,-3.356) 9(1.25,-3.356) 10(1.75,-3.356) 11(2.25,-3.356) 26(2.25,3.356) 27(1.75,3.356) 28(1.25,3.356) 29(0.75,3.356) 30(0.25,3.356) 31(-0.25,3.356) 32(-0.75,3.356) 33(-1.25,3.356) 34(-1.75,3.356) 35(-2.25,3.356)
  rect 0.787x0.254 smd: 14(3.356,-2.25) 15(3.356,-1.75) 16(3.356,-1.25) 17(3.356,-0.75) 18(3.356,-0.25) 19(3.356,0.25) 20(3.356,0.75) 21(3.356,1.25) 22(3.356,1.75) 23(3.356,2.25) 38(-3.356,2.25) 39(-3.356,1.75) 40(-3.356,1.25) 41(-3.356,0.75) 42(-3.356,0.25) 43(-3.356,-0.25) 44(-3.356,-0.75) 45(-3.356,-1.25) 46(-3.356,-1.75) 47(-3.356,-2.25)
  rect 4.801x4.801 smd: PAD(0,0)
QFN68_8X8_PAD6_25X6_25
  oval 0.229x0.711 smd: 1(-3.2,-3.901) 2(-2.8,-3.901) 3(-2.4,-3.901) 4(-2,-3.901) 5(-1.6,-3.901) 6(-1.2,-3.901) 7(-0.8,-3.901) 8(-0.4,-3.901) 9(0,-3.901) 10(0.4,-3.901) 11(0.8,-3.901) 12(1.2,-3.901) 13(1.6,-3.901) 14(2,-3.901) 15(2.4,-3.901) 16(2.8,-3.901) 17(3.2,-3.901) 35(3.2,3.901) 36(2.8,3.901) 37(2.4,3.901) 38(2,3.901) 39(1.6,3.901) 40(1.2,3.901) 41(0.8,3.901) 42(0.4,3.901) 43(0,3.901) 44(-0.4,3.901) 45(-0.8,3.901) 46(-1.2,3.901) 47(-1.6,3.901) 48(-2,3.901) 49(-2.4,3.901) 50(-2.8,3.901) 51(-3.2,3.901)
  oval 0.711x0.229 smd: 18(3.901,-3.2) 19(3.901,-2.8) 20(3.901,-2.4) 21(3.901,-2) 22(3.901,-1.6) 23(3.901,-1.2) 24(3.901,-0.8) 25(3.901,-0.4) 26(3.901,0) 27(3.901,0.4) 28(3.901,0.8) 29(3.901,1.2) 30(3.901,1.6) 31(3.901,2) 32(3.901,2.4) 33(3.901,2.8) 34(3.901,3.2) 52(-3.901,3.2) 53(-3.901,2.8) 54(-3.901,2.4) 55(-3.901,2) 56(-3.901,1.6) 57(-3.901,1.2) 58(-3.901,0.8) 59(-3.901,0.4) 60(-3.901,0) 61(-3.901,-0.4) 62(-3.901,-0.8) 63(-3.901,-1.2) 64(-3.901,-1.6) 65(-3.901,-2) 66(-3.901,-2.4) 67(-3.901,-2.8) 68(-3.901,-3.2)
  rect 6.248x6.248 smd: PAD(0,0)
QFP80_12X12_PAD5_81X5_81
  rect 0.305x1.168 smd: 1(-4.75,-6.619) 2(-4.25,-6.619) 3(-3.75,-6.619) 4(-3.25,-6.619) 5(-2.75,-6.619) 6(-2.25,-6.619) 7(-1.75,-6.619) 8(-1.25,-6.619) 9(-0.75,-6.619) 10(-0.25,-6.619) 11(0.25,-6.619) 12(0.75,-6.619) 13(1.25,-6.619) 14(1.75,-6.619) 15(2.25,-6.619) 16(2.75,-6.619) 17(3.25,-6.619) 18(3.75,-6.619) 19(4.25,-6.619) 20(4.75,-6.619) 41(4.75,6.619) 42(4.25,6.619) 43(3.75,6.619) 44(3.25,6.619) 45(2.75,6.619) 46(2.25,6.619) 47(1.75,6.619) 48(1.25,6.619) 49(0.75,6.619) 50(0.25,6.619) 51(-0.25,6.619) 52(-0.75,6.619) 53(-1.25,6.619) 54(-1.75,6.619) 55(-2.25,6.619) 56(-2.75,6.619) 57(-3.25,6.619) 58(-3.75,6.619) 59(-4.25,6.619) 60(-4.75,6.619)
  rect 1.168x0.305 smd: 21(6.619,-4.75) 22(6.619,-4.25) 23(6.619,-3.75) 24(6.619,-3.25) 25(6.619,-2.75) 26(6.619,-2.25) 27(6.619,-1.75) 28(6.619,-1.25) 29(6.619,-0.75) 30(6.619,-0.25) 31(6.619,0.25) 32(6.619,0.75) 33(6.619,1.25) 34(6.619,1.75) 35(6.619,2.25) 36(6.619,2.75) 37(6.619,3.25) 38(6.619,3.75) 39(6.619,4.25) 40(6.619,4.75) 61(-6.619,4.75) 62(-6.619,4.25) 63(-6.619,3.75) 64(-6.619,3.25) 65(-6.619,2.75) 66(-6.619,2.25) 67(-6.619,1.75) 68(-6.619,1.25) 69(-6.619,0.75) 70(-6.619,0.25) 71(-6.619,-0.25) 72(-6.619,-0.75) 73(-6.619,-1.25) 74(-6.619,-1.75) 75(-6.619,-2.25) 76(-6.619,-2.75) 77(-6.619,-3.25) 78(-6.619,-3.75) 79(-6.619,-4.25) 80(-6.619,-4.75)
  rect 5.817x5.817 smd: PAD(0,0)
R0402
  rect 0.635x0.737 smd: 1(-0.5,0) 2(0.5,0)
R0603
  rect 0.787x0.991 smd: 1(-0.85,0) 2(0.85,0)
R0603H35
  rect 0.813x0.813 smd: 1(-0.907,0) 2(0.907,0)
R0805
  rect 1.041x1.397 smd: 1(-0.95,0) 2(0.95,0)
R1206
  rect 1.041x1.753 smd: 1(-1.5,0) 2(1.5,0)
R2512-2
  rect 3.048x3.505 smd: 1(-2.324,0) 2(2.324,0)
R5329
  rect 4.496x3.404 smd: 1(-7.748,0) 2(7.748,0)
RSML3307W787H124_6FS
  round 9.652 hole 8.382 unplated: (-30,0) (30,0)
  rect 5.41x2.997 hole 1.499: I1N(4.95,3.5) I1P(-4.95,3.5) I2N(4.95,-3.5) I2P(-4.95,-3.5) NG(4.95,0) PG(-4.95,0)
  custom 3.15x3.15 hole 1.499: N(11.6,0) N1(-11.6,0)
SMA-2
  rect 2.489x1.702 smd: A(1.995,0) C(-1.995,0)
SO8
  rect 0.61x2.184 smd: 1(-1.905,-2.54) 2(-0.635,-2.54) 3(0.635,-2.54) 4(1.905,-2.54) 5(1.905,2.54) 6(0.635,2.54) 7(-0.635,2.54) 8(-1.905,2.54)
SO8WB_A
  rect 0.61x1.549 smd: 1(-1.905,-4.85) 2(-0.635,-4.85) 3(0.635,-4.85) 4(1.905,-4.85) 5(1.905,4.85) 6(0.635,4.85) 7(-0.635,4.85) 8(-1.905,4.85)
SOD123-2
  rect 0.914x1.219 smd: A(1.638,0) C(-1.638,0)
SOD123F
  rect 1.194x1.194 smd: A(1.403,0) C(-1.403,0)
SOD123FL
  rect 0.914x1.219 smd: A(1.638,0) C(-1.638,0)
SOD128
  rect 0.991x1.93 smd: A(2.21,0) C(-2.21,0)
SOD323-5
  rect 0.61x0.61 smd: 1(-1.1,0) 2(1.1,0)
SOD523_B
  rect 0.813x0.61 smd: A(0.85,0) C(-0.85,0)
SOT23_6
  rect 0.711x1.27 smd: 1(-0.953,-1.27) 2(0,-1.27) 3(0.953,-1.27) 4(0.953,1.27) 5(0,1.27) 6(-0.953,1.27)
SOT23_6-3
  rect 0.635x1.067 smd: 1(-0.95,-1.1) 2(0,-1.1) 3(0.95,-1.1) 4(0.95,1.1) 5(0,1.1) 6(-0.95,1.1)
SOT23_B
  rect 0.61x1.041 smd: 1(-0.958,-1.15) 2(0.958,-1.15) 3(0,1.15)
SOT223_A
  rect 0.889x1.803 smd: 1(-2.3,-3) 2(0,-3) 3(2.3,-3)
  rect 3.2x1.803 smd: 4(0,3)
SWSML118W98H69
  rect 0.787x1.702 smd: 1(-1.694,0) 2(1.694,0)
TO263-3
  rect 1.346x4.597 smd: 1(-2.548,-4.574) 3(2.548,-4.574)
  rect 10.795x9.398 smd: 2(0,4.574)
TPC63D35
  round 1.6 hole 0.889: 1(0,0)
TSML400W295H340
  rect 1.168x2.083 smd: 1(-2.489,5.829) 2(0,5.829) 3(2.489,5.829) 4(2.489,-5.829) 5(0,-5.829) 6(-2.489,-5.829)
TSML510W280H215
  rect 0.762x1.905 smd: 1(-4.445,-4.381) 2(-3.175,-4.381) 3(-1.905,-4.381) 4(-0.635,-4.381) 5(0.635,-4.381) 6(1.905,-4.381) 7(3.175,-4.381) 8(4.445,-4.381) 9(4.445,4.381) 10(3.175,4.381) 11(1.905,4.381) 12(0.635,4.381) 13(-0.635,4.381) 14(-1.905,4.381) 15(-3.175,4.381) 16(-4.445,4.381)
TSOT-5
  rect 0.508x1.524 smd: 1(-0.95,-1.17) 2(0,-1.17) 3(0.95,-1.17) 4(0.95,1.17) 5(-0.95,1.17)
unnamed#2
  round 1.016 smd: (0,0)
WLCSP4H26
  round 0.203 smd: A1(-0.2,-0.2) A2(-0.2,0.2) B1(0.2,-0.2) B2(0.2,0.2)
YSML63W47H14
  rect 0.66x0.559 smd: 1(-0.55,-0.4) 2(0.55,-0.4) 3(0.55,0.4) 4(-0.55,0.4)
YSML65W41H20
  rect 0.508x0.991 smd: 1(-0.554,0) 2(0.554,0)

## Nets
1V1_VCORE: C277.1 P17.2(N2) R349.2(N2) U22.44
1V2_VBLE: C256.1 P22.2(N2) R348.2(N2) U17.A2(VOUT)
1V8_VDD: C279.1 P18.2(N2) R315.1 R347.2(N2) U22.45
3V3_LDO: C276.1 P15.2(N2) U22.42
3V3_VDD: C212.1 C228.1 C229.1 C252.1 C253.1 C254.1 C268.2(N2) C291.2(N2) E7.1 E8.1 P20.1 P21.2(N2) R199.1 R200.1 R224.1 R225.1 R316.1 R346.2(N2) R382.2(N2) U8.8 U10.6 U10.30 U16.A1 U16.B1 U17.A1 U17.B1 U18.A1 U18.B1 U19.3(VCC) U20.3 U20.4
GND1: C32.2(N2) C64.2(N2) C65.2(N2) C66.2(N2) C68.2(N2) C69.2(N2) C70.2(N2) C71.2(N2) C72.2(N2) C73.2(N2) C74.2(N2) C75.2(N2) C76.2(N2) C77.2(N2) C78.2(N2) C79.2(N2) C80.2(N2) C81.2(N2) C82.2(N2) C83.2(N2) C84.2(N2) C85.2(N2) C86.2(N2) C87.2(N2) C88.2(N2) C89.2(N2) C90.2(N2) C91.2(N2) C92.2(N2) C93.2(N2) C94.2(N2) C181.2(N2) C189.2(N2) C190.2(N2) C191.2(N2) C296.2(N2) C297.2(N2) C298.2(N2) C299.2(N2) C300.2(N2) C301.2(N2) C302.2(N2) C303.2(N2) C304.2(N2) C305.2(N2) C306.2(N2) C307.2(N2) C308.2(N2) C309.2(N2) C310.2(N2) C311.2(N2) C312.2(N2) C313.2(N2) C314.2(N2) C315.2(N2) C316.1 D1.1 D2.1 D3.1 D4.1 D33.A(P) P2.2 P2.4 P2.6 P2.8(N8) P3.2 P3.4 P3.6 P3.8(N8) R41.1 R57.1 R339.1 R343.1 U1.61 U1.64 U1.67 U1.PAD U2.4 U2.7(WP)
GND2: C126.2(N2) C158.2(N2) C159.2(N2) C160.2(N2) C161.2(N2) C162.2(N2) C163.2(N2) C164.2(N2) C165.2(N2) C166.2(N2) C167.2(N2) C168.2(N2) C169.2(N2) C170.2(N2) C171.2(N2) C172.2(N2) C173.2(N2) C174.2(N2) C175.2(N2) C176.2(N2) C177.2(N2) C178.2(N2) C179.2(N2) C180.2(N2) C182.1 C183.1 C184.1 C185.2(N2) C186.2(N2) C187.2(N2) C188.2(N2) C192.2(N2) C193.1 C194.2(N2) C195.2(N2) C196.2(N2) C197.N(N2) C198.2(N2) C199.2(N2) C200.2(N2) C201.2(N2) C202.2(N2) C203.2(N2) C204.2(N2) C205.2(N2) C206.2(N2) C207.2(N2) C208.2(N2) C209.2(N2) C210.2(N2) C211.2(N2) C214.2(N2) C230.N(N2) C231.2(N2) C232.2(N2) C233.2(N2) C235.2(N2) C236.N(N2) C237.2(N2) C238.2(N2) C239.2(N2) C241.2(N2) C242.N(N2) C243.2(N2) C244.2(N2) C245.2(N2) C246.2(N2) C258.2(N2) C259.2(N2) C260.2(N2) C261.2(N2) C262.2(N2) C263.2(N2) C264.2(N2) C265.2(N2) C266.2(N2) C267.2(N2) C317.2(N2) C318.2(N2) C319.2(N2) C320.2(N2) C321.2(N2) C322.2(N2) C323.2(N2) C324.2(N2) C325.2(N2) C326.2(N2) C327.2(N2) C328.2(N2) C329.2(N2) C330.2(N2) C331.2(N2) C332.2(N2) C333.2(N2) C334.2(N2) C335.2(N2) C336.1 C337.2(N2) C338.2(N2) C339.2(N2) C340.2(N2) C341.2(N2) C342.1 C343.1 C344.1 C345.1 C346.2(N2) C347.1 C348.2(N2) C352.2(N2) C353.1 C354.2(N2) C355.1 C356.1 C357.1 C358.1 C359.1 D5.1 D6.1 D7.1 D8.1 D9.1 D10.1 D11.1 D12.1 D23.A(P) D50.A(P) D66.A(P) D67.1 D74.A(P) P4.18 P4.19 P5.2 P5.4 P5.6 P5.8(N8) P6.2 P6.4 P6.6 P6.8(N8) P7.2 P7.4 P7.6 P7.8 P7.10 P8.2 P8.4 P8.6 P8.8 P8.10 P9.2 P9.4 P9.6 P9.8 P9.10 R126.1 R142.1 R180.2(N2) R185.1 R218.2(N2) R240.2(N2) R246.2(N2) R256.2(N2) R262.2(N2) R272.2(N2) R278.2(N2) R288.2(N2) R294.2(N2) R304.2(N2) R310.2(N2) R344.1 R375.N R375.NG R375.PG R389.1 R391.1 R393.2(N2) R395.2(N2) RT1.2(N2) RT2.1 TP3.1(N1) U3.61 U3.64 U3.67 U3.PAD U4.4 U4.7(WP) U5.21 U5.24 U5.44 U5.46 U5.47 U5.PAD U6.6(VPRG2) U6.8 U6.12 U6.16 U6.PAD U7.4 U7.7(WP) U8.4 U9.2 U11.2(VCCUV) U11.3 U11.5 U11.PAD U12.2(VCCUV) U12.3 U12.5 U12.PAD U13.2(VCCUV) U13.3 U13.5 U13.PAD
GND_ISO: C212.2(N2) C215.2(N2) C216.2(N2) C217.2(N2) C218.2(N2) C219.2(N2) C220.2(N2) C221.2(N2) C222.2(N2) C223.2(N2) C224.2(N2) C225.2(N2) C226.2(N2) C227.2(N2) C228.2(N2) C229.2(N2) C248.1 C249.2(N2) C251.2(N2) C252.2(N2) C253.2(N2) C254.2(N2) C255.2(N2) C256.2(N2) C257.2(N2) C268.1 C269.2(N2) C270.2(N2) C271.2(N2) C272.2(N2) C273.2(N2) C274.1 C275.1 C276.2(N2) C277.2(N2) C278.2(N2) C279.2(N2) C280.1 C281.1 C282.1 C283.1 C284.1 C285.1 C286.2(N2) C287.1 C288.1 C290.1 C292.1 C293.1 C294.1 C295.1 D13.1 D14.1 D15.1 D16.1 D20.A(P) DS3.C DS4.C DS5.C DS6.C L3.1 P10.3(N3) P11.5 P12.3 P12.5 P12.9 P13.12 P20.3(N3) R211.2(N2) R213.2(N2) R214.2(N2) R215.2(N2) R216.2(N2) R217.2(N2) R218.1 R230.2(N2) R313.1 R320.2(N2) R321.1 R321.2(N2) R323.1 R324.1 S1.2(B) T4.4 U8.5 U10.9 U10.17 U10.PAD U14.3 U15.3 U15.5 U15.PAD U16.B2 U17.B2 U18.B2 U19.2 U19.PAD U21.2 U22.52 U22.54 U22.PAD Y2.2 Y2.4
VBAT+: F1.1 R177.1 TP16.1(N1)
VBATTP: C197.P C199.1 C214.1 D17.A(P) D22.C D66.C P1.1 R1.2(N2) R58.1 R59.1 R187.1 R337.2(N2) T4.3 U6.3 U9.1 U9.5(VIN)
VBUS: C287.2(N2) C288.2(N2) C290.2(N2) L2.1 R229.2(N2) U14.5 U21.5
VDD: C215.1 C248.2(N2) D19.C D20.C TP8.1(N1) U14.4(VCCEN) U14.6
VDDIO: C281.2(N2) C283.2(N2) P12.1 P19.2(N2) U22.11 U22.22 U22.63
VDDIOH: C282.2(N2) C284.2(N2) P16.2(N2) U22.12 U22.19 U22.65
0P9: P14.11 P20.2 R350.1
0P10: P14.12 R351.1 U10.8
0P23: P13.1 R352.1 U10.32
1P7: P13.2 R353.1
1P8: P13.3 R354.1
1P9: P13.4 R355.1
1P10: P13.5 R356.1 R398.1 U10.1
1P11: P13.6 R357.1
1P12: P13.7 R358.1
1P15: P13.8 R359.1
1P16: P13.9(N9) R360.1
1P18: P13.10 R361.1
1P19: P13.11 R362.1
1P20: P14.1 R363.1
1P21: P14.2 R364.1
2P7: P14.3 R365.1
2P8: P14.4 R366.1
2P24: P14.7 R369.1
2P25: P14.8 R370.1
3P4: P14.9(N9) R371.1
4P0: P14.10 R372.1
ADBMS6822_IM1: C222.1 R208.2(N2) U10.10
ADBMS6822_IM2: C223.1 R209.2(N2) U10.18
ADBMS6822_IP1: C220.1 R204.2(N2) U10.11
ADBMS6822_IP2: C221.1 R205.2(N2) U10.19
BATT1_CELL1: C31.2(N2) C32.1 P1.17 R40.1 R55.1 R56.1
BATT1_CELL2: C30.2(N2) C31.1 P1.16 R38.1 R39.1 R53.1 R54.1
BATT1_CELL3: C29.2(N2) C30.1 P1.15 R37.1 R51.1 R52.1
BATT1_CELL4: C28.2(N2) C29.1 P1.14 R35.1 R36.1 R49.1 R50.1
BATT1_CELL5: C27.2(N2) C28.1 P1.13 R34.1 R47.1 R48.1
BATT1_CELL6: C26.2(N2) C27.1 P1.12 R32.1 R33.1 R45.1 R46.1
BATT1_CELL7: C25.2(N2) C26.1 P1.11 R31.1 R43.1 R44.1
BATT1_CELL8: C8.2(N2) C25.1 P1.10 R13.1 R29.1 R30.1 R42.1
BATT1_CELL9: C7.2(N2) C8.1 P1.9(N9) R12.1 R27.1 R28.1
BATT1_CELL10: C6.2(N2) C7.1 P1.8 R10.1 R11.1 R25.1 R26.1
BATT1_CELL11: C5.2(N2) C6.1 P1.7 R9.1 R23.1 R24.1
BATT1_CELL12: C4.2(N2) C5.1 P1.6 R7.1 R8.1 R21.1 R22.1
BATT1_CELL13: C3.2(N2) C4.1 P1.5 R6.1 R19.1 R20.1
BATT1_CELL14: C2.2(N2) C3.1 P1.4 R4.1 R5.1 R17.1 R18.1
BATT1_CELL15: C1.2(N2) C2.1 D21.A(P) P1.3 R3.1 R15.1 R16.1
BATT1_CELL16: C1.1 P1.2 R2.1 R14.1 R337.1
BATT2_CELL1: C125.2(N2) C126.1 P4.17 R125.1 R140.1 R141.1
BATT2_CELL2: C124.2(N2) C125.1 P4.16 R123.1 R124.1 R138.1 R139.1
BATT2_CELL3: C123.2(N2) C124.1 P4.15 R122.1 R136.1 R137.1
BATT2_CELL4: C122.2(N2) C123.1 P4.14 R120.1 R121.1 R134.1 R135.1
BATT2_CELL5: C121.2(N2) C122.1 P4.13 R119.1 R132.1 R133.1
BATT2_CELL6: C120.2(N2) C121.1 P4.12 R117.1 R118.1 R130.1 R131.1
BATT2_CELL7: C119.2(N2) C120.1 P4.11 R116.1 R128.1 R129.1
BATT2_CELL8: C102.2(N2) C119.1 P4.10 R98.1 R114.1 R115.1 R127.1
BATT2_CELL9: C101.2(N2) C102.1 P4.9(N9) R97.1 R112.1 R113.1
BATT2_CELL10: C100.2(N2) C101.1 P4.8 R95.1 R96.1 R110.1 R111.1
BATT2_CELL11: C99.2(N2) C100.1 P4.7 R94.1 R108.1 R109.1
BATT2_CELL12: C98.2(N2) C99.1 P4.6 R92.1 R93.1 R106.1 R107.1
BATT2_CELL13: C97.2(N2) C98.1 P4.5 R91.1 R104.1 R105.1
BATT2_CELL14: C96.2(N2) C97.1 P4.4 R89.1 R90.1 R102.1 R103.1
BATT2_CELL15: C95.2(N2) C96.1 D24.A(P) P4.3 R88.1 R100.1 R101.1
BATT2_CELL16: C95.1 P4.1 P4.2 R87.1 R99.1 R143.1 R144.1 R340.1 R342.1
BMS1_C1: C40.2(N2) R41.2(N2) U1.57
BMS1_C2: C39.1 R39.2(N2) U1.51
BMS1_C2_1: C39.2(N2) C40.1 C304.1 R40.2(N2) U1.54
BMS1_C3: C38.2(N2) R38.2(N2) U1.50
BMS1_C4: C37.1 R36.2(N2) U1.44
BMS1_C4_3: C37.2(N2) C38.1 C311.1 R37.2(N2) U1.47
BMS1_C5: C36.2(N2) R35.2(N2) U1.43
BMS1_C6: C35.1 R33.2(N2) U1.37
BMS1_C6_5: C35.2(N2) C36.1 C307.1 R34.2(N2) U1.40
BMS1_C7: C34.2(N2) R32.2(N2) U1.36
BMS1_C8: C33.1 R30.2(N2) U1.30
BMS1_C8_7: C33.2(N2) C34.1 C314.1 R31.2(N2) U1.33
BMS1_C9: C16.2(N2) R13.2(N2) U1.29
BMS1_C10: C15.1 R11.2(N2) U1.23
BMS1_C10_9: C15.2(N2) C16.1 C302.1 R12.2(N2) U1.26
BMS1_C11: C14.2(N2) R10.2(N2) U1.22
BMS1_C12: C13.1 R8.2(N2) U1.16
BMS1_C12_11: C13.2(N2) C14.1 C190.1 R9.2(N2) U1.19
BMS1_C13: C12.2(N2) R7.2(N2) U1.15
BMS1_C14: C11.1 R5.2(N2) U1.9
BMS1_C14_13: C11.2(N2) C12.1 C191.1 R6.2(N2) U1.12
BMS1_C15: C10.2(N2) R4.2(N2) U1.8
BMS1_C16: C9.1 R2.2(N2) U1.2
BMS1_C16_15: C9.2(N2) C10.1 C299.1 R3.2(N2) U1.5
BMS1_DRIVE: C68.1 R61.1 U1.65
BMS1_GPIO7: C72.1 R64.1 U1.74
BMS1_GPIO7_INPUT: C80.1 P3.1 R64.2(N2) R72.2(N2)
BMS1_GPIO8: C74.1 R66.1 U1.73
BMS1_GPIO8_INPUT: C82.1 P3.3 R66.2(N2) R74.2(N2)
BMS1_GPIO9: C76.1 R68.1 U1.72
BMS1_GPIO9_INPUT: C84.1 P3.5 R68.2(N2) R76.2(N2)
BMS1_GPIO10: C78.1 R70.1 U1.71
BMS1_GPIO10_INPUT: C86.1 P3.7 R70.2(N2) R78.2(N2)
BMS1_I2C_SCL: R60.2(N2) U1.76 U2.6
BMS1_I2C_SDA: R62.2(N2) U1.77 U2.5
BMS1_IMA: C87.1 R79.1 U1.58
BMS1_IMA_ISO: T1.1 T2.6
BMS1_IMB: C88.1 R80.1 U1.62
BMS1_IMB_ISO: T1.6 T5.3
BMS1_IPA: C89.1 R81.1 U1.59
BMS1_IPA_ISO: T1.3 T2.8
BMS1_IPB: C90.1 R82.1 U1.63
BMS1_IPB_ISO: T1.8 T5.1
BMS1_NTC1: C71.1 R63.1 U1.80
BMS1_NTC2: C73.1 R65.1 U1.79
BMS1_NTC3: C75.1 R67.1 U1.78
BMS1_NTC4: C77.1 R69.1 U1.75
BMS1_S1N: C48.2(N2) D36.2 R57.2(N2) U1.55
BMS1_S1P: C48.1 C63.2(N2) C64.1 C305.1 D36.1 R56.2(N2) U1.56
BMS1_S2N: C47.2(N2) D41.2 R55.2(N2) U1.52
BMS1_S2P: C47.1 C62.2(N2) C63.1 C309.1 D41.1 R54.2(N2) U1.53
BMS1_S3N: C46.2(N2) D39.2 R53.2(N2) U1.48
BMS1_S3P: C46.1 C61.2(N2) C62.1 C310.1 D39.1 R52.2(N2) U1.49
BMS1_S4N: C45.2(N2) D35.2 R51.2(N2) U1.45
BMS1_S4P: C45.1 C60.2(N2) C61.1 C313.1 D35.1 R50.2(N2) U1.46
BMS1_S5N: C44.2(N2) D34.2 R49.2(N2) U1.41
BMS1_S5P: C44.1 C59.2(N2) C60.1 C306.1 D34.1 R48.2(N2) U1.42
BMS1_S6N: C43.2(N2) D40.2 R47.2(N2) U1.38
BMS1_S6P: C43.1 C58.2(N2) C59.1 C308.1 D40.1 R46.2(N2) U1.39
BMS1_S7N: C42.2(N2) D38.2 R45.2(N2) U1.34
BMS1_S7P: C42.1 C57.2(N2) C58.1 C312.1 D38.1 R44.2(N2) U1.35
BMS1_S8N: C41.2(N2) D37.2 R43.2(N2) U1.31
BMS1_S8P: C41.1 C56.2(N2) C57.1 C315.1 D37.1 R42.2(N2) U1.32
BMS1_S9N: C24.2(N2) D25.2 R29.2(N2) U1.27
BMS1_S9P: C24.1 C55.2(N2) C56.1 C181.1 D25.1 R28.2(N2) U1.28
BMS1_S10N: C23.2(N2) D26.2 R27.2(N2) U1.24
BMS1_S10P: C23.1 C54.2(N2) C55.1 C303.1 D26.1 R26.2(N2) U1.25
BMS1_S11N: C22.2(N2) D27.2 R25.2(N2) U1.20
BMS1_S11P: C22.1 C53.2(N2) C54.1 C189.1 D27.1 R24.2(N2) U1.21
BMS1_S12N: C21.2(N2) D28.2 R23.2(N2) U1.17
BMS1_S12P: C21.1 C52.2(N2) C53.1 C301.1 D28.1 R22.2(N2) U1.18
BMS1_S13N: C20.2(N2) D29.2 R21.2(N2) U1.13
BMS1_S13P: C20.1 C51.2(N2) C52.1 C297.1 D29.1 R20.2(N2) U1.14
BMS1_S14N: C19.2(N2) D30.2 R19.2(N2) U1.10
BMS1_S14P: C19.1 C50.2(N2) C51.1 C296.1 D30.1 R18.2(N2) U1.11
BMS1_S15N: C18.2(N2) D31.2 R17.2(N2) U1.6
BMS1_S15P: C18.1 C49.2(N2) C50.1 C300.1 D31.1 R16.2(N2) U1.7
BMS1_S16N: C17.2(N2) D32.2 R15.2(N2) U1.3
BMS1_S16P: C17.1 C49.1 C298.1 D32.1 R14.2(N2) U1.4
BMS1_VREF2: C66.1 E2.1 E3.1 U1.68
BMS1_VREG: C69.1 C70.1 E1.2(N2) R60.1 R62.1 TP2.1(N1) U1.60 U1.69(VREG) U2.8
BMS2_C1: C134.2(N2) R126.2(N2) U3.57
BMS2_C2: C133.1 R124.2(N2) U3.51
BMS2_C2_1: C133.2(N2) C134.1 C333.1 R125.2(N2) U3.54
BMS2_C3: C132.2(N2) R123.2(N2) U3.50
BMS2_C4: C131.1 R121.2(N2) U3.44
BMS2_C4_3: C131.2(N2) C132.1 C338.1 R122.2(N2) U3.47
BMS2_C5: C130.2(N2) R120.2(N2) U3.43
BMS2_C6: C129.1 R118.2(N2) U3.37
BMS2_C6_5: C129.2(N2) C130.1 C340.1 R119.2(N2) U3.40
BMS2_C7: C128.2(N2) R117.2(N2) U3.36
BMS2_C8: C127.1 R115.2(N2) U3.30
BMS2_C8_7: C127.2(N2) C128.1 C330.1 R116.2(N2) U3.33
BMS2_C9: C110.2(N2) R98.2(N2) U3.29
BMS2_C10: C109.1 R96.2(N2) U3.23
BMS2_C10_9: C109.2(N2) C110.1 C323.1 R97.2(N2) U3.26
BMS2_C11: C108.2(N2) R95.2(N2) U3.22
BMS2_C12: C107.1 R93.2(N2) U3.16
BMS2_C12_11: C107.2(N2) C108.1 C326.1 R94.2(N2) U3.19
BMS2_C13: C106.2(N2) R92.2(N2) U3.15
BMS2_C14: C105.1 R90.2(N2) U3.9
BMS2_C14_13: C105.2(N2) C106.1 C320.1 R91.2(N2) U3.12
BMS2_C15: C104.2(N2) R89.2(N2) U3.8
BMS2_C16: C103.1 R87.2(N2) U3.2
BMS2_C16_15: C103.2(N2) C104.1 C318.1 R88.2(N2) U3.5
BMS2_DRIVE: C162.1 R146.1 U3.65
BMS2_GPIO7: C166.1 R149.1 U3.74
BMS2_GPIO7_INPUT: C174.1 P6.1 R149.2(N2) R157.2(N2) R393.1 R394.2(N2)
BMS2_GPIO8: C168.1 R151.1 U3.73
BMS2_GPIO8_INPUT: C176.1 P6.3 R151.2(N2) R159.2(N2) R389.2(N2) R397.1
BMS2_GPIO9: C170.1 R153.1 U3.72
BMS2_GPIO9_INPUT: C178.1 P6.5 R153.2(N2) R161.2(N2) R390.1 R391.2(N2)
BMS2_GPIO10: C172.1 R155.1 U3.71
BMS2_GPIO10_INPUT: C180.1 P6.7 R155.2(N2) R163.2(N2) R395.1 R396.2(N2)
BMS2_I2C_SCL: R145.2(N2) U3.76 U4.6
BMS2_I2C_SDA: R147.2(N2) U3.77 U4.5
BMS2_IMA: C182.2(N2) R164.1 U3.58
BMS2_IMB: C183.2(N2) R165.1 U3.62
BMS2_IPA: C184.2(N2) R166.1 U3.59
BMS2_IPB: C336.2(N2) R167.1 U3.63
BMS2_NTC1: C165.1 R148.1 U3.80
BMS2_NTC2: C167.1 R150.1 U3.79
BMS2_NTC3: C169.1 R152.1 U3.78
BMS2_NTC4: C171.1 R154.1 U3.75
BMS2_S1N: C142.2(N2) D52.2 R142.2(N2) U3.55
BMS2_S1P: C142.1 C157.2(N2) C158.1 C334.1 D52.1 R141.2(N2) U3.56
BMS2_S2N: C141.2(N2) D55.2 R140.2(N2) U3.52
BMS2_S2P: C141.1 C156.2(N2) C157.1 C339.1 D55.1 R139.2(N2) U3.53
BMS2_S3N: C140.2(N2) D58.2 R138.2(N2) U3.48
BMS2_S3P: C140.1 C155.2(N2) C156.1 C332.1 D58.1 R137.2(N2) U3.49
BMS2_S4N: C139.2(N2) D54.2 R136.2(N2) U3.45
BMS2_S4P: C139.1 C154.2(N2) C155.1 C337.1 D54.1 R135.2(N2) U3.46
BMS2_S5N: C138.2(N2) D51.2 R134.2(N2) U3.41
BMS2_S5P: C138.1 C153.2(N2) C154.1 C341.1 D51.1 R133.2(N2) U3.42
BMS2_S6N: C137.2(N2) D57.2 R132.2(N2) U3.38
BMS2_S6P: C137.1 C152.2(N2) C153.1 C335.1 D57.1 R131.2(N2) U3.39
BMS2_S7N: C136.2(N2) D56.2 R130.2(N2) U3.34
BMS2_S7P: C136.1 C151.2(N2) C152.1 C331.1 D56.1 R129.2(N2) U3.35
BMS2_S8N: C135.2(N2) D53.2 R128.2(N2) U3.31
BMS2_S8P: C135.1 C150.2(N2) C151.1 C329.1 D53.1 R127.2(N2) U3.32
BMS2_S9N: C118.2(N2) D42.2 R114.2(N2) U3.27
BMS2_S9P: C118.1 C149.2(N2) C150.1 C324.1 D42.1 R113.2(N2) U3.28
BMS2_S10N: C117.2(N2) D43.2 R112.2(N2) U3.24
BMS2_S10P: C117.1 C148.2(N2) C149.1 C322.1 D43.1 R111.2(N2) U3.25
BMS2_S11N: C116.2(N2) D44.2 R110.2(N2) U3.20
BMS2_S11P: C116.1 C147.2(N2) C148.1 C327.1 D44.1 R109.2(N2) U3.21
BMS2_S12N: C115.2(N2) D45.2 R108.2(N2) U3.17
BMS2_S12P: C115.1 C146.2(N2) C147.1 C325.1 D45.1 R107.2(N2) U3.18
BMS2_S13N: C114.2(N2) D46.2 R106.2(N2) U3.13
BMS2_S13P: C114.1 C145.2(N2) C146.1 C321.1 D46.1 R105.2(N2) U3.14
BMS2_S14N: C113.2(N2) D47.2 R104.2(N2) U3.10
BMS2_S14P: C113.1 C144.2(N2) C145.1 C328.1 D47.1 R103.2(N2) U3.11
BMS2_S15N: C112.2(N2) D48.2 R102.2(N2) U3.6
BMS2_S15P: C112.1 C143.2(N2) C144.1 C319.1 D48.1 R101.2(N2) U3.7
BMS2_S16N: C111.2(N2) D49.2 R100.2(N2) U3.3
BMS2_S16P: C111.1 C143.1 C317.1 D49.1 R99.2(N2) U3.4
BMS2_V-: C67.2(N2) D22.A(P) D23.C P1.18 P1.19 R339.2(N2) R340.2(N2) R341.2(N2) R342.2(N2) TP1.1(N1)
BMS2_VREF2: C160.1 E5.1 R392.1 U3.68
BMS2_VREG: C163.1 C164.1 E4.2(N2) R145.1 R147.1 R338.1 TP4.1(N1) U3.60 U3.69(VREG) U4.8
BMS3_1P25: C195.1 R172.2(N2) R183.2(N2) R233.1 R234.1 R249.1 R250.1 R265.1 R266.1 R281.1 R282.1 R297.1 R298.1 U5.15
BMS3_GPIO1: P9.1 U5.28
BMS3_GPIO2: P9.3 U5.29
BMS3_GPO4: P9.5 U5.35
BMS3_GPO5: P9.7 U5.37
BMS3_GPO6: P9.9(N9) U5.39
BMS3_I2C_SCL: R186.2(N2) R331.2(N2) U7.6
BMS3_I2C_SDA: R188.2(N2) R330.2(N2) U7.5
BMS3_IMA: C205.1 R191.1 U5.27
BMS3_IMA_ISO: T3.3 T5.8
BMS3_IMB: C206.1 R192.1 U5.23
BMS3_IMB_ISO: T2.1 T3.8
BMS3_IPA: C203.1 R189.1 U5.26
BMS3_IPA_ISO: T3.1 T5.6
BMS3_IPB: C204.1 R190.1 U5.22
BMS3_IPB_ISO: T2.3 T3.6
BMS3_OCA: R197.2(N2) U5.36 U8.2
BMS3_OCB: R198.2(N2) U5.38 U8.3
BMS3_V1: C258.1 R247.2(N2) U5.48
BMS3_V2: C260.1 R263.2(N2) U5.2
BMS3_V3: C262.1 R279.2(N2) U5.10
BMS3_V4: C264.1 R295.2(N2) U5.18
BMS3_V5: C266.1 R311.2(N2) U5.6
BMS3_V6: C259.1 R248.2(N2) U5.16
BMS3_V7: C261.1 R173.2(N2) R264.2(N2) U5.17
BMS3_V8: C263.1 R280.2(N2) U5.13
BMS3_V9: C265.1 R181.1 R296.2(N2) U5.19
BMS3_V10: C267.1 R312.2(N2) U5.20
BMS3_VBAT1: R179.2(N2) R180.1 R184.1
BMS3_VREG: C200.1 C201.1 C202.1 C211.1 C231.1 C237.1 C243.1 L1.2(N2) R186.1 R188.1 R197.1 R198.1 TP7.1(N1) U5.25 U5.40 U5.42(VREG) U6.9 U7.8 U8.1 U11.1 U12.1 U13.1
CHARGE_FET_INP: U5.32 U13.4
DISCHARGE_FET_INP: U5.33 U11.4
HYP_CLKN: R374.1 TP6.1(N1)
HYP_CLKP: R373.1 TP5.1(N1)
I1A: C357.2(N2) R327.2(N2) U5.3
I1AS: C351.1 C352.1 L6.1 L6.2 R327.1 R328.1 R375.I1P
I1B: C343.2(N2) R174.1 U5.4
I1BS: C348.1 C351.2(N2) L6.3 L6.4(N4) R174.2(N2) R375.I1N
I2A: C356.2(N2) R325.2(N2) U5.7
I2AS: C350.1 C354.1 L5.1 L5.2 R325.1 R329.1 R375.I2P R376.1
I2B: C345.2(N2) R176.1 U5.8
I2BS: C346.1 C350.2(N2) L5.3 L5.4(N4) R176.2(N2) R182.1 R375.I2N
I3A: C355.2(N2) R326.2(N2) U5.1
I3AS: C349.1 C353.2(N2) L4.1 L4.2 R326.1 R376.2(N2)
I3B: C344.2(N2) R175.1 U5.11
I3BS: C347.2(N2) C349.2(N2) L4.3 L4.4(N4) R175.2(N2) R182.2(N2)
LINKP_IN: C247.2(N2) D63.C D64.C D65.C D67.2(N2) D71.C D72.C D73.C Q5.2 Q7.2 Q8.2 Q9.2 Q13.2 Q14.2 Q15.2 R345.2(N2) R390.2(N2) TP11.1(N1) TP12.1(N1)
LINKP_OUT: C234.2(N2) C242.P C244.1 C245.1 C246.1 D59.C D60.C D62.C D68.C D69.C D70.C Q3.3(S) Q4.3(S) Q5.3(S) Q6.3(S) Q8.3(S) Q9.3(S) Q10.3(S) Q11.3(S) Q12.3(S) Q13.3(S) Q14.3(S) Q15.3(S) R397.2(N2) TP9.1(N1) TP10.1(N1) U11.8
LPUART_RX: R220.1 TP15.1(N1)
LPUART_TX: R219.2(N2) U22.40
MCU_32KIN: C292.2(N2) U22.47 Y1.1
MCU_32KOUT: C294.2(N2) U22.48 Y1.2(N2)
MCU_CAN0B_RX: U19.4 U22.34
MCU_CAN0B_TX: R314.2(N2) U22.33
MCU_HFX_OUT: C295.2(N2) U22.58 Y2.3(N2)
MCU_HFXIN: C293.2(N2) U22.57 Y2.1
MCU_INTR1: U10.7 U22.7
MCU_INTR2: U10.31 U22.8
MCU_OC1: R199.2(N2) U8.7 U22.23
MCU_OC2: R200.2(N2) U8.6(VOB) U22.32
MCU_RSTN: P12.10(N5) S1.1 U22.59
MCU_SPI1A_CS0: R224.2(N2) R332.1 U10.5
MCU_SPI1A_CS1: R225.2(N2) R335.1 U10.29
MCU_SPI1A_MISO: R336.1 U10.3 U10.27
MCU_SPI1A_MOSI: R333.1 U10.2 U10.26
MCU_SPI1A_SCK: R334.1 U10.4 U10.28
MCU_USB_DM: P11.2 U21.4 U21.6(NC_2) U22.37
MCU_USB_DP: P11.3 U21.1 U21.3 U22.36
PRECHARGE_FET_INP: U5.34 U12.4
PRECHARGE_IN: C230.P C232.1 C233.1 C235.1 C236.P C238.1 C239.1 C241.1 F1.2(N2) Q3.2 Q4.2 Q6.2 Q10.2 Q11.2 Q12.2 R377.1 R378.1 R379.1 R394.1
S1A: C359.2(N2) R328.2(N2) U5.5
S2A: C358.2(N2) R329.2(N2) U5.9
SWCLK: P12.4 R318.1 U22.61
SWDIO: P12.2 R317.1 U22.62
UART_RX: P12.8 P14.5 R367.1
UART_TX: P12.6 P14.6 R368.1
UNNAMED_2_DIO3PV14_I258_C: D25.3(C) D26.3(C) D27.3(C) D28.3(C) D29.3(C) D30.3(C) D31.3(C) D32.3(C) D33.C D34.3(C) D35.3(C) D36.3(C) D37.3(C) D38.3(C) D39.3(C) D40.3(C) D41.3(C)
UNNAMED_2_DIO_I187_N: D21.C R1.1
UNNAMED_3_ADBMS6830_I2_V: C67.1 R58.2(N2) U1.1
UNNAMED_3_ADBMS6830_I2_V_1: R343.2(N2) U1.66
UNNAMED_3_ADBMS6830_I2_VREF1: C65.1 U1.70
UNNAMED_3_DIOLED_I56_N: C316.2(N2) DS1.C Q1.2 Q1.4
UNNAMED_3_FERRITE_I13_N1: E1.1 Q1.3(E)
UNNAMED_3_RES_I11_N2: DS1.A(P) R59.2(N2)
UNNAMED_3_RES_I14_N2: Q1.1 R61.2(N2)
UNNAMED_4_CAP_I8_N1: C85.1 P2.7 R69.2(N2) R77.2(N2)
UNNAMED_4_CAP_I10_N1: C83.1 P2.5 R67.2(N2) R75.2(N2)
UNNAMED_4_CAP_I12_N1: C81.1 P2.3 R65.2(N2) R73.2(N2)
UNNAMED_4_CAP_I15_N1: C79.1 P2.1 R63.2(N2) R71.2(N2)
UNNAMED_4_FERRITE_I19_N2: E2.2(N2) R71.1 R73.1 R75.1 R77.1
UNNAMED_4_FERRITE_I40_N2: E3.2(N2) R72.1 R74.1 R76.1 R78.1
UNNAMED_5_CAP_I6_N1: C91.1 R83.2(N2) R85.2(N2)
UNNAMED_5_CAP_I18_N1: C93.1 T1.15
UNNAMED_5_CAP_I20_N1: C94.1 T1.10
UNNAMED_5_CAP_I32_N1: C92.1 R84.2(N2) R86.2(N2)
UNNAMED_5_DIOZNRV3_I10_N2: D1.2(N2) R79.2(N2) R83.1 T1.16
UNNAMED_5_DIOZNRV3_I28_N2: D4.2(N2) R82.2(N2) R86.1 T1.9
UNNAMED_5_DIOZNRV3_I30_N2: D2.2(N2) R80.2(N2) R84.1 T1.11
UNNAMED_5_RES_I2_N2: D3.2(N2) R81.2(N2) R85.1 T1.14
UNNAMED_6_DIO3PV14_I197_C: D42.3(C) D43.3(C) D44.3(C) D45.3(C) D46.3(C) D47.3(C) D48.3(C) D49.3(C) D50.C D51.3(C) D52.3(C) D53.3(C) D54.3(C) D55.3(C) D56.3(C) D57.3(C) D58.3(C)
UNNAMED_6_DIO_I173_N: D24.C R341.1
UNNAMED_7_ADBMS6830_I8_V: C161.1 R143.2(N2) U3.1
UNNAMED_7_ADBMS6830_I8_V_1: R344.2(N2) U3.66
UNNAMED_7_ADBMS6830_I8_VREF1: C159.1 U3.70
UNNAMED_7_DIOLED_I14_N: C342.2(N2) DS2.C Q2.2 Q2.4
UNNAMED_7_DIOLED_I14_P: DS2.A(P) R144.2(N2)
UNNAMED_7_FERRITE_I18_N1: E4.1 Q2.3(E)
UNNAMED_7_RES_I13_N2: Q2.1 R146.2(N2)
UNNAMED_8_CAP_I38_N1: C173.1 P5.1 R148.2(N2) R156.2(N2)
UNNAMED_8_CAP_I40_N1: C175.1 P5.3 R150.2(N2) R158.2(N2)
UNNAMED_8_CAP_I45_N1: C177.1 P5.5 R152.2(N2) R160.2(N2)
UNNAMED_8_CAP_I47_N1: C179.1 P5.7 R154.2(N2) R162.2(N2)
UNNAMED_8_FERRITE_I5_N1: E6.1 R338.2(N2) R392.2(N2)
UNNAMED_8_FERRITE_I5_N2: E6.2(N2) R157.1 R159.1 R161.1 R163.1
UNNAMED_8_FERRITE_I10_N2: E5.2(N2) R156.1 R158.1 R160.1 R162.1
UNNAMED_9_CAP_I9_N1: C186.1 R169.2(N2) R171.2(N2)
UNNAMED_9_CAP_I18_N1: C188.1 T2.10
UNNAMED_9_CAP_I27_N1: C185.1 R168.2(N2) R170.2(N2)
UNNAMED_9_CAP_I32_N1: C187.1 T2.15
UNNAMED_9_DIOZNRV3_I11_N2: D6.2(N2) R165.2(N2) R169.1 T2.11
UNNAMED_9_DIOZNRV3_I29_N2: D5.2(N2) R164.2(N2) R168.1 T2.16
UNNAMED_9_RES_I15_N1: D8.2(N2) R167.2(N2) R171.1 T2.9
UNNAMED_9_RES_I25_N2: D7.2(N2) R166.2(N2) R170.1 T2.14
UNNAMED_10_ADBMS2950_I1_GPIO3: R330.1 U5.30
UNNAMED_10_ADBMS2950_I1_GPIO4: R331.1 U5.31
UNNAMED_10_ADBMS2950_I1_VBAT1: C192.1 R184.2(N2) U5.12
UNNAMED_10_ADBMS2950_I1_VBAT2: C193.2(N2) R185.2(N2) U5.14
UNNAMED_10_ADBMS2950_I1_VREF1: C196.1 U5.45
UNNAMED_10_ADBMS2950_I1_VREF2: C194.1 U5.43
UNNAMED_10_ADLTC3639_I78_RUN: R187.2(N2) U6.14
UNNAMED_10_ADLTC3639_I78_SS: C198.1 U6.7 U6.10
UNNAMED_10_ADLTC3639_I78_SW: L1.1 U6.1
UNNAMED_10_CNTP1P_I140_N1: R375.N1 TP13.1(N1)
UNNAMED_10_RES_I48_N2: R177.2(N2) R178.1
UNNAMED_10_RES_I49_N2: R178.2(N2) R179.1
UNNAMED_10_RES_I125_N1: R181.2(N2) R183.1 RT2.2(N2)
UNNAMED_10_RES_I128_N1: R172.1 R173.1 RT1.1
UNNAMED_11_CAP_I9_N1: C208.1 R194.2(N2) R196.2(N2)
UNNAMED_11_CAP_I18_N1: C210.1 T3.10
UNNAMED_11_CAP_I26_N1: C207.1 R193.2(N2) R195.2(N2)
UNNAMED_11_CAP_I31_N1: C209.1 T3.15
UNNAMED_11_DIOZNRV3_I11_N2: D10.2(N2) R190.2(N2) R194.1 T3.11
UNNAMED_11_DIOZNRV3_I28_N2: D9.2(N2) R189.2(N2) R193.1 T3.16
UNNAMED_11_RES_I15_N1: D12.2(N2) R192.2(N2) R196.1 T3.9
UNNAMED_11_RES_I24_N2: D11.2(N2) R191.2(N2) R195.1 T3.14
UNNAMED_12_ADLT8303_I103_RFB: R201.1 U9.3
UNNAMED_12_ADLT8303_I103_SW: D18.A(P) R201.2(N2) T4.1 U9.4
UNNAMED_12_CAP_I34_N1: C217.1 T5.10
UNNAMED_12_CAP_I41_N1: C219.1 R203.2(N2) R207.2(N2)
UNNAMED_12_CAP_I60_N1: C216.1 T5.15
UNNAMED_12_CAP_I62_N1: C218.1 R202.2(N2) R206.2(N2)
UNNAMED_12_DIOSCHOTTKY_I117_P: D19.A(P) T4.6
UNNAMED_12_DIOSCHOTTKY_I133_N: D17.C D18.C
UNNAMED_12_DIOZNRV3_I36_N2: D16.2(N2) R207.1 R209.1 T5.9
UNNAMED_12_DIOZNRV3_I38_N2: D14.2(N2) R203.1 R205.1 T5.11
UNNAMED_12_DIOZNRV3_I58_N2: D15.2(N2) R206.1 R208.1 T5.14
UNNAMED_12_DIOZNRV3_I59_N2: D13.2(N2) R202.1 R204.1 T5.16
UNNAMED_13_ADBMS6822_I1_PHAPOL: R210.2(N2) R211.1 U10.14
UNNAMED_13_ADBMS6822_I1_RTO: R216.1 U10.15
UNNAMED_13_ADBMS6822_I1_VDD: C224.1 C226.1 E7.2(N2) R210.1 R398.2(N2) U10.12 U10.13
UNNAMED_13_ADBMS6822_I1_XCVRMD: R214.1 U10.16
UNNAMED_13_ADBMS6822_I36_MSTR2: C225.1 C227.1 E8.2(N2) R212.1 U10.20 U10.21 U10.25
UNNAMED_13_ADBMS6822_I36_PHAPOL2: R212.2(N2) R213.1 U10.22
UNNAMED_13_ADBMS6822_I36_RTO2: R217.1 U10.23
UNNAMED_13_ADBMS6822_I36_XCVRMD2: R215.1 U10.24(XCVRMD2)
UNNAMED_15_ADLTC7001_I1_BST: C240.1 U12.9
UNNAMED_15_ADLTC7001_I1_TGDN: R227.2(N2) U12.6 U12.7
UNNAMED_15_ADLTC7001_I1_TS: C240.2(N2) D61.C Q7.3(S) R377.2(N2) R378.2(N2) R379.2(N2) R396.1 U12.8
UNNAMED_15_ADLTC7001_I21_BST: C234.1 U11.9
UNNAMED_15_ADLTC7001_I21_TGDN: R221.2(N2) R222.2(N2) R226.2(N2) R383.2(N2) R384.2(N2) R385.2(N2) U11.6 U11.7
UNNAMED_15_ADLTC7001_I38_BST: C247.1 U13.9
UNNAMED_15_ADLTC7001_I38_TGDN: R223.2(N2) R228.2(N2) R380.2(N2) U13.6 U13.7
UNNAMED_15_ADLTC7001_I38_TS: D74.C R345.1 U13.8
UNNAMED_15_DIOTVS_I115_P: D70.A(P) Q12.1 R385.1
UNNAMED_15_DIOTVS_I119_P: D69.A(P) Q11.1 R384.1
UNNAMED_15_DIOTVS_I121_P: D68.A(P) Q10.1 R383.1
UNNAMED_15_DIOTVS_I124_P: D71.A(P) Q13.1 R386.1
UNNAMED_15_DIOTVS_I127_P: D73.A(P) Q15.1 R388.1
UNNAMED_15_DIOTVS_I129_P: D72.A(P) Q14.1 R387.1
UNNAMED_15_RES_I5_N1: D61.A(P) Q7.1 R227.1
UNNAMED_15_RES_I19_N1: D59.A(P) Q3.1 R226.1
UNNAMED_15_RES_I36_N1: D63.A(P) Q5.1 R228.1
UNNAMED_15_RES_I77_N1: D60.A(P) Q4.1 R221.1
UNNAMED_15_RES_I81_N1: D64.A(P) Q8.1 R223.1
UNNAMED_15_RES_I83_N1: D65.A(P) Q9.1 R380.1
UNNAMED_15_RES_I90_N1: D62.A(P) Q6.1 R222.1
UNNAMED_15_RES_I128_N2: R386.2(N2) R387.2(N2) R388.2(N2)
UNNAMED_16_ADMAX20337_I52_COM: C249.1 U14.1 U15.1 U15.2 U15.4
UNNAMED_16_ADMAX25301A_I5_BYP: C250.1 U15.8
UNNAMED_16_ADMAX25301A_I5_OUT1: C250.2(N2) C251.1 R231.2(N2) R381.1 R382.1 U15.7 U15.9 U15.10
UNNAMED_16_ADP151V2_I3_VOUT: C257.1 P17.1 U18.A2(VOUT)
UNNAMED_16_ADP151V2_I4_VOUT: C255.1 P18.1 R232.2(N2) U16.A2(VOUT)
UNNAMED_16_CN2P_I55_N1: P15.1 R381.2(N2)
UNNAMED_16_CN2P_I57_N1: P16.1 R231.1
UNNAMED_16_CN2P_I59_N1: P19.1 R232.1
UNNAMED_16_DIOLED_I40_P: DS4.A(P) R347.1
UNNAMED_16_DIOLED_I44_P: DS5.A(P) R348.1
UNNAMED_16_DIOLED_I47_P: DS6.A(P) R349.1
UNNAMED_16_DIOLED_I51_P: DS3.A(P) R346.1
UNNAMED_16_RES_I36_N1: R229.1 R230.1 U14.2
UNNAMED_17_RES_I1_N2: R235.2(N2) R236.1
UNNAMED_17_RES_I3_N2: R236.2(N2) R237.1
UNNAMED_17_RES_I4_N2: R237.2(N2) R238.1
UNNAMED_17_RES_I6_N2: R233.2(N2) R239.2(N2) R240.1
UNNAMED_17_RES_I10_N1: R238.2(N2) R239.1 R247.1
UNNAMED_17_RES_I14_N2: R241.2(N2) R242.1
UNNAMED_17_RES_I15_N2: R242.2(N2) R243.1
UNNAMED_17_RES_I16_N2: R243.2(N2) R244.1
UNNAMED_17_RES_I17_N2: R244.2(N2) R245.1 R248.1
UNNAMED_17_RES_I18_N2: R234.2(N2) R245.2(N2) R246.1
UNNAMED_17_RES_I24_N1: R251.2(N2) R252.1
UNNAMED_17_RES_I24_N2: R252.2(N2) R253.1
UNNAMED_17_RES_I25_N2: R253.2(N2) R254.1
UNNAMED_17_RES_I27_N2: R254.2(N2) R255.1 R263.1
UNNAMED_17_RES_I28_N2: R249.2(N2) R255.2(N2) R256.1
UNNAMED_17_RES_I37_N2: R257.2(N2) R258.1
UNNAMED_17_RES_I38_N2: R258.2(N2) R259.1
UNNAMED_17_RES_I39_N2: R259.2(N2) R260.1
UNNAMED_17_RES_I40_N1: R260.2(N2) R261.1 R264.1
UNNAMED_17_RES_I42_N2: R250.2(N2) R261.2(N2) R262.1
UNNAMED_17_RES_I46_N2: R283.2(N2) R284.1
UNNAMED_17_RES_I47_N2: R284.2(N2) R285.1
UNNAMED_17_RES_I48_N2: R267.2(N2) R268.1
UNNAMED_17_RES_I49_N2: R268.2(N2) R269.1
UNNAMED_17_RES_I50_N1: R286.2(N2) R287.1 R295.1
UNNAMED_17_RES_I53_N2: R285.2(N2) R286.1
UNNAMED_17_RES_I55_N2: R281.2(N2) R287.2(N2) R288.1
UNNAMED_17_RES_I59_N2: R289.2(N2) R290.1
UNNAMED_17_RES_I60_N2: R290.2(N2) R291.1
UNNAMED_17_RES_I61_N2: R291.2(N2) R292.1
UNNAMED_17_RES_I64_N1: R292.2(N2) R293.1 R296.1
UNNAMED_17_RES_I68_N2: R282.2(N2) R293.2(N2) R294.1
UNNAMED_17_RES_I74_N2: R269.2(N2) R270.1
UNNAMED_17_RES_I75_N2: R270.2(N2) R271.1 R279.1
UNNAMED_17_RES_I77_N2: R265.2(N2) R271.2(N2) R272.1
UNNAMED_17_RES_I81_N2: R273.2(N2) R274.1
UNNAMED_17_RES_I82_N2: R274.2(N2) R275.1
UNNAMED_17_RES_I83_N2: R275.2(N2) R276.1
UNNAMED_17_RES_I84_N1: R276.2(N2) R277.1 R280.1
UNNAMED_17_RES_I86_N2: R266.2(N2) R277.2(N2) R278.1
UNNAMED_17_RES_I90_N2: R299.2(N2) R300.1
UNNAMED_17_RES_I91_N2: R300.2(N2) R301.1
UNNAMED_17_RES_I92_N2: R301.2(N2) R302.1
UNNAMED_17_RES_I93_N2: R302.2(N2) R303.1 R311.1
UNNAMED_17_RES_I100_N2: R297.2(N2) R303.2(N2) R304.1
UNNAMED_17_RES_I101_N2: R305.2(N2) R306.1
UNNAMED_17_RES_I102_N2: R306.2(N2) R307.1
UNNAMED_17_RES_I103_N2: R307.2(N2) R308.1
UNNAMED_17_RES_I104_N1: R308.2(N2) R309.1 R312.1
UNNAMED_17_RES_I106_N2: R298.2(N2) R309.2(N2) R310.1
UNNAMED_18_ADLTC2875_I77_CANH: P10.2 R319.2(N2) U19.7
UNNAMED_18_ADLTC2875_I77_CANL: P10.1 R319.1 U19.6
UNNAMED_18_ADLTC2875_I77_RS: R313.2(N2) U19.8
UNNAMED_18_ADLTC2875_I77_TXD: R314.1 U19.1
UNNAMED_18_ADMAX32690V2_I1_ANT: C285.2(N2) U22.53
UNNAMED_18_ADMAX32690V2_I1_BLELDOIN: C275.2(N2) C280.2(N2) P22.1 U22.50
UNNAMED_18_ADMAX32690V2_I1_HYPCLKN: R374.2(N2) U22.28
UNNAMED_18_ADMAX32690V2_I1_HYPCLKP: R373.2(N2) U22.29
UNNAMED_18_ADMAX32690V2_I1_P0: R332.2(N2) U22.14
UNNAMED_18_ADMAX32690V2_I1_P0_1: R352.2(N2) U22.13
UNNAMED_18_ADMAX32690V2_I1_P0_2: R351.2(N2) U22.10
UNNAMED_18_ADMAX32690V2_I1_P0_3: R350.2(N2) U22.9
UNNAMED_18_ADMAX32690V2_I1_P1: R364.2(N2) U22.31
UNNAMED_18_ADMAX32690V2_I1_P1_1: R363.2(N2) U22.30
UNNAMED_18_ADMAX32690V2_I1_P1_2: R362.2(N2) U22.26
UNNAMED_18_ADMAX32690V2_I1_P1_3: R361.2(N2) U22.27
UNNAMED_18_ADMAX32690V2_I1_P1_4: R360.2(N2) U22.25
UNNAMED_18_ADMAX32690V2_I1_P1_5: R359.2(N2) U22.24
UNNAMED_18_ADMAX32690V2_I1_P1_6: R358.2(N2) U22.21
UNNAMED_18_ADMAX32690V2_I1_P1_7: R357.2(N2) U22.20
UNNAMED_18_ADMAX32690V2_I1_P1_8: R356.2(N2) U22.16
UNNAMED_18_ADMAX32690V2_I1_P1_9: R355.2(N2) U22.15
UNNAMED_18_ADMAX32690V2_I1_P1_10: R354.2(N2) U22.18
UNNAMED_18_ADMAX32690V2_I1_P1_11: R353.2(N2) U22.17
UNNAMED_18_ADMAX32690V2_I1_P2: R334.2(N2) U22.4
UNNAMED_18_ADMAX32690V2_I1_P2_1: R333.2(N2) U22.5
UNNAMED_18_ADMAX32690V2_I1_P2_2: R336.2(N2) U22.3
UNNAMED_18_ADMAX32690V2_I1_P2_3: R335.2(N2) U22.68
UNNAMED_18_ADMAX32690V2_I1_P2_4: R370.2(N2) U22.6
UNNAMED_18_ADMAX32690V2_I1_P2_5: R369.2(N2) U22.64
UNNAMED_18_ADMAX32690V2_I1_P2_6: R368.2(N2) U22.67
UNNAMED_18_ADMAX32690V2_I1_P2_7: R367.2(N2) U22.66
UNNAMED_18_ADMAX32690V2_I1_P2_8: R366.2(N2) U22.2
UNNAMED_18_ADMAX32690V2_I1_P2_9: R365.2(N2) U22.1
