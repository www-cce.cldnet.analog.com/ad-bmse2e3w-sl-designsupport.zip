# Allegro board AD-BMSE2E3W-SL Allegro Project File.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
BMS2_V- on TOP: 125.35,99.19 128.78,95.76 161.29,95.76 161.42,95.63 161.42,95 161.93,94.49 161.93,90.93 125.73,90.93 120.27,96.39 17.78,96.39 16.13,94.74 16.13,88.52 4.57,88.52 4.45,88.65 4.45,92.58 10.67,92.58 17.27,99.19
BMS2_V- on L4_POWER: outline of 288 points within 4.29,36.96 50.04,90.68
BMS2_VREF2 on TOP: 101.6,19.18 101.6,17.53 103.63,17.53 103.63,19.18
BMS2_VREF2 on L4_POWER: 125.86,40 120.27,40 120.27,36.7 121.54,36.7 121.79,36.45 121.79,19.68 99.87,19.68 99.49,19.3 99.49,17.53 125.86,17.53
BMS2_VREG on TOP: 101.47,21.59 101.47,19.56 102.74,19.56 102.74,21.59
BMS2_VREG on TOP: 118.95,28.17 119.91,28.17 119.91,25.58 117.17,25.58 116.76,25.98 116.76,27.91 117.07,28.22 118.9,28.22
BMS2_VREG on L4_POWER: 119,27.81 117.22,29.59 117.22,40.77 119.76,40.77 120.27,40.26 131.95,40.26 131.95,30.48 132.33,30.1 137.54,30.1 137.54,45.08 113.41,45.08 113.41,22.99 113.28,22.86 101.85,22.86 101.35,22.35 101.35,19.94 118.75,19.94 119,20.19
BMS3_1P25 on L4_POWER: 208.51,30.61 208.51,27.1 182.3,27.1 181.53,26.34 181.53,19.94 157.25,19.94 157.1,20.09 157.1,26.54 178.54,26.54 178.54,30.61
BMS3_VBAT1 on TOP: 210.06,20.83 213.36,20.83 213.36,23.11 210.06,23.11
BMS3_VBAT1 on BOTTOM: 186.41,21.36 186.41,24 187.17,24 187.17,21.36
BMS3_VBAT1 on L4_POWER: 185.67,24.76 185.67,20.19 213.11,20.19 213.11,24.76
BMS3_VREG on TOP: 215.9,49.66 218.57,49.66 218.57,43.69 217.17,42.29 217.17,39.88 217.42,39.62 220.13,39.62 220.13,38.35 217.42,38.35 217.17,38.1 217.17,32.51 214.12,32.51 214.12,42.42 215.9,44.2
BMS3_VREG on TOP: 138.71,20.35 140.44,20.35 140.44,20.32 161.54,20.32 161.54,7.16 162.28,6.43 162.28,4.44 161.52,4.44 161.52,5.51 160.55,6.48 157,6.48 157,9.02 158.62,9.02 158.62,12.32 158.12,12.83 139.57,12.83 138.94,12.19 138.94,9.55 138.76,9.37 138.76,7.85 137.9,7.85 137.9,8.92 136.02,10.79 136.02,14.2 138.68,16.87 138.68,20.32 138.71,20.32
BMS3_VREG on TOP: 205.92,37.72 206.48,37.72 206.48,36.14 206.68,35.94 206.68,34.06 207.39,33.35 210.08,33.35 210.08,31.78 210.03,31.72 205.82,31.72 205.77,31.78 205.77,35.99 205.92,36.14
BMS3_VREG on L5_POWER: 212.66,30.73 176.15,30.73 174.42,29.01 174.42,18.11 174.82,17.72 172.21,17.72 172.21,12.7 178.49,12.7 178.49,8.25 167.01,8.25 167.01,9.52 161.29,9.52 161.29,7.45 161.23,7.39 157.99,7.39 157.96,7.37 154.56,7.37 154.56,10.74 152.83,12.47 136.83,12.47 136.83,17.2 162.33,17.2 169.14,24 169.14,34.16 210.82,34.16 213.87,37.21 214.63,37.21 214.63,44.45 215.14,44.96 215.33,44.96 215.33,49.53 217.04,49.53 217.04,33.65 212.85,33.65 212.66,33.46
CHARGE_FET_INP on L4_POWER: outline of 103 points within 173.36,10.54 223.01,38.23
DISCHARGE_FET_INP on L5_POWER: 175.01,26.16 175.01,17.78 173.23,16 173.23,13.08 176.66,13.08 176.78,13.21 176.78,23.49 217.17,23.49 217.17,31.11 214.12,31.11 214.12,26.29 214,26.16
LINKP_IN on TOP: 224.23,43.18 224.17,43.2 224.14,43.25 224.16,43.27 224.16,43.35 224.31,43.5 224.31,44.53 221.08,44.53 220.98,44.63 220.98,46.53 221.03,46.53 221.44,46.99 221.03,47.45 220.99,47.45 220.98,47.46 220.98,52.83 221.03,52.83 221.17,52.87 221.29,52.95 221.36,52.98 221.44,52.94 221.51,52.89 221.59,52.87 222.38,52.87 222.52,52.93 222.58,53.07 222.58,54.06 222.52,54.21 222.38,54.27 221.59,54.27 221.45,54.21 221.39,54.07 221.38,54.03 221.26,54.03 221.19,54.02 221.11,54 221.02,54.02 220.98,54.1 220.98,54.61 219.19,54.61 219.18,54.65 219.15,54.75 219.09,54.83 218.35,55.57 218.35,56.78 218.29,56.93 218.15,56.99 217,56.99 216.86,56.93 216.8,56.78 216.8,54.98 216.86,54.83 217,54.77 218.21,54.77 218.29,54.7 218.3,54.64 218.25,54.61 215.37,54.61 215.37,100.96 242.57,100.96 242.57,100.96 243.84,100.96 243.84,64.13 257.3,64.13 257.3,91.44 272.54,91.44 272.54,54.61 228.6,54.61 228.6,43.18
LINKP_IN on BOTTOM: 217.17,100.96 242.57,100.96 242.57,100.96 243.84,100.96 243.84,64.13 257.18,64.13 257.18,91.44 271.78,91.44 271.78,54.61 215.27,54.61 215.27,100.96
LINKP_IN on L3_SIGNAL: 217.17,100.96 242.57,100.96 242.57,100.96 243.84,100.96 243.84,64.13 257.3,64.13 257.3,91.44 271.78,91.44 271.78,54.61 227.33,54.61 227.33,42.54 220.98,42.54 220.98,54.61 215.27,54.61 215.27,100.96
LINKP_IN on L4_POWER: 217.17,100.96 242.57,100.96 242.57,100.96 243.84,100.96 243.84,64.13 257.3,64.13 257.3,91.44 271.78,91.44 271.78,54.61 229.24,54.61 229.24,46.99 221.62,46.99 221.62,54.48 221.49,54.61 215.27,54.61 215.27,100.96
LINKP_IN on L5_POWER: 242.57,100.96 243.84,100.96 243.84,64.13 257.3,64.13 257.3,91.44 271.78,91.44 271.78,54.61 229.24,54.61 229.24,46.99 221.62,46.99 221.62,50.93 220.98,50.93 220.98,54.61 215.37,54.61 215.37,100.96 242.57,100.96
LINKP_IN on L6_SIGNAL: 217.17,100.96 242.57,100.96 242.57,100.96 243.84,100.96 243.84,64.13 257.18,64.13 257.18,91.44 271.78,91.44 271.78,54.61 226.7,54.61 226.7,44.45 220.98,44.45 220.98,54.61 215.27,54.61 215.27,100.96
LINKP_OUT on TOP: 292.74,100.96 292.74,10.16 282.57,10.16 282.57,45.08 269.24,45.08 269.24,18.41 256.54,18.41 256.54,48.89 235.59,48.89 235.59,22.22 222.5,22.22 222.5,30.73 221.87,31.37 221.87,31.75 229.87,31.75 229.87,53.34 273.05,53.34 273.05,92.71 256.03,92.71 256.03,65.4 244.48,65.4 244.48,100.96 258.44,100.96
LINKP_OUT on BOTTOM: 245.75,100.96 258.44,100.96 290.83,100.96 292.74,100.96 292.74,10.16 282.57,10.16 282.57,45.08 269.24,45.08 269.24,18.41 256.54,18.41 256.54,48.89 235.59,48.89 235.59,22.22 221.62,22.22 221.62,31.11 224.16,31.11 224.16,48.89 230.51,48.89 230.51,53.34 273.05,53.34 273.05,92.07 261.62,92.07 261.62,66.04 260.99,65.4 244.48,65.4 244.48,100.96
LINKP_OUT on L3_SIGNAL: 245.75,100.96 258.44,100.96 290.83,100.96 292.74,100.96 292.74,10.16 282.57,10.16 282.57,45.08 269.24,45.08 269.24,14.6 256.54,14.6 256.54,48.89 235.59,48.89 235.59,22.22 221.62,22.22 221.62,37.46 228.6,37.46 228.6,53.34 273.05,53.34 273.05,92.71 256.41,92.71 256.41,65.4 244.48,65.4 244.48,100.96
LINKP_OUT on L4_POWER: 245.75,100.96 258.44,100.96 290.83,100.96 292.74,100.96 292.74,10.16 282.57,10.16 282.57,45.08 269.24,45.08 269.24,18.41 256.54,18.41 256.54,48.89 235.59,48.89 235.59,22.22 221.62,22.22 221.62,31.11 224.79,31.11 224.79,53.34 273.05,53.34 273.05,92.07 261.62,92.07 261.62,66.04 260.99,65.4 244.48,65.4 244.48,100.96
LINKP_OUT on L5_POWER: 245.75,100.96 258.44,100.96 290.83,100.96 292.74,100.96 292.74,10.16 282.57,10.16 282.57,45.08 269.24,45.08 269.24,18.41 256.54,18.41 256.54,48.89 235.59,48.89 235.59,22.22 221.62,22.22 221.62,45.72 224.79,45.72 224.79,53.34 273.05,53.34 273.05,92.71 256.03,92.71 256.03,65.4 244.48,65.4 244.48,100.96
LINKP_OUT on L6_SIGNAL: 245.75,100.96 258.44,100.96 290.83,100.96 292.74,100.96 292.74,7.62 282.57,7.62 282.57,45.08 269.24,45.08 269.24,18.41 256.54,18.41 256.54,48.89 235.59,48.89 235.59,22.22 221.62,22.22 221.62,43.81 224.79,43.81 224.79,53.34 273.05,53.34 273.05,92.07 261.62,92.07 261.62,66.04 260.99,65.4 244.48,65.4 244.48,100.96
PRECHARGE_FET_INP on L5_POWER: 172.85,12.83 172.85,11.43 213.49,11.43 213.49,18.03 221.11,18.03 221.11,34.8 220.35,35.56 220.35,49.66 217.68,49.66 217.68,19.56 217.42,19.3 184.28,19.3 184.28,13.21 183.9,12.83
PRECHARGE_IN on TOP: 225.43,5.08 225.43,11.68 217.93,11.68 217.81,11.81 217.81,17.14 240.67,17.14 240.67,47.62 255.27,47.62 255.27,16.51 270.51,16.51 270.51,43.81 281.94,43.81 281.94,8.89 281.31,8.89 281.31,5.08
PRECHARGE_IN on BOTTOM: 219.08,5.08 219.08,17.14 240.67,17.14 240.67,47.62 255.27,47.62 255.27,16.51 270.51,16.51 270.51,43.81 281.94,43.81 281.94,9.52 281.31,9.52 281.31,5.08
PRECHARGE_IN on L3_SIGNAL: 240.67,17.14 240.67,47.62 255.27,47.62 255.27,13.97 270.51,13.97 270.51,43.81 281.94,43.81 281.94,8.89 281.31,8.89 281.31,7.62 219.08,7.62 219.08,17.14
PRECHARGE_IN on L4_POWER: 226.31,5.08 226.31,7.62 219.08,7.62 219.08,17.14 240.67,17.14 240.67,47.62 255.27,47.62 255.27,16.51 270.51,16.51 270.51,43.81 281.94,43.81 281.94,5.08
PRECHARGE_IN on L5_POWER: 219.08,5.08 219.08,17.14 240.67,17.14 240.67,47.62 255.27,47.62 255.27,16.51 270.51,16.51 270.51,43.81 281.94,43.81 281.94,10.16 281.31,10.16 281.31,5.08
PRECHARGE_IN on L6_SIGNAL: 225.81,5.08 219.08,11.81 219.08,17.14 240.67,17.14 240.67,47.62 255.27,47.62 255.27,17.14 270.51,17.14 270.51,43.81 281.94,43.81 281.94,9.52 281.31,9.52 281.31,5.08
UNNAMED_3_DIOLED_I56_N on TOP: 40.92,30.96 40.92,28.37 41.73,28.37 41.73,30.05 41.88,30.2 46.2,30.2 46.2,27.05 50.88,27.05 50.88,34.16 46.2,34.16 46.2,31.01 40.97,31.01
UNNAMED_3_DIOLED_I56_N on BOTTOM: 46.2,28.96 50.93,28.96 50.93,34.16 46.2,34.16
UNNAMED_3_DIOLED_I56_N on L3_SIGNAL: 46.2,34.16 46.2,27.05 50.93,27.05 50.93,34.16
UNNAMED_3_DIOLED_I56_N on L6_SIGNAL: 46.2,27.05 50.93,27.05 50.93,34.16 46.2,34.16
UNNAMED_3_RES_I11_N2 on TOP: 37.92,31.01 37.92,30.25 40.06,30.25 40.06,31.01
UNNAMED_7_DIOLED_I14_N on TOP: 121.74,30.2 125.87,30.2 125.87,27.05 130.56,27.05 130.56,34.16 125.87,34.16 125.87,31.01 121.79,31.01 121.59,31.22 120.68,31.22 120.68,29.74 120.62,29.69 120.62,28.73 121.49,28.73 121.49,29.95
UNNAMED_7_DIOLED_I14_N on BOTTOM: 125.87,27.05 130.05,27.05 130.05,34.16 125.87,34.16
UNNAMED_7_DIOLED_I14_N on L3_SIGNAL, L6_SIGNAL: 125.87,27.05 130.6,27.05 130.6,34.16 125.87,34.16
UNNAMED_7_DIOLED_I14_P on TOP: 117.63,31.32 119,31.32 119.1,31.22 119.86,31.22 119.86,30.45 118.39,30.45 118.34,30.4 117.63,30.4
UNNAMED_15_ADLTC7001_I1_TS on BOTTOM: 229.24,48.89 225.43,48.89 225.43,28.57 229.24,28.57
UNNAMED_15_ADLTC7001_I21_TGDN on TOP: 220.35,31.11 220.35,29.21 221.74,29.21 221.74,31.11
UNNAMED_16_ADP151V2_I3_VOUT on TOP: 168.12,75.34 168.17,75.29 168.86,75.29 169.01,75.44 169.01,76.1 169.16,76.25 172.39,76.25 172.49,76.35 172.49,77.39 168.12,77.39
UNNAMED_16_ADP151V2_I3_VOUT on L5_POWER: 161.77,78.21 161.77,74.6 172.64,74.6 172.69,74.65 172.69,78.21
UNNAMED_16_ADP151V2_I4_VOUT on TOP: 168.12,85.34 168.17,85.29 168.86,85.29 169.01,85.45 169.01,86.11 169.16,86.26 171.07,86.26 171.07,87.4 169.19,87.4 168.22,88.37 168.22,89.38 167.46,89.38 167.46,88.42 168.12,87.76
UNNAMED_16_ADP151V2_I4_VOUT on L5_POWER: 161.77,80.9 166.45,80.9 166.45,85.37 166.95,85.88 169.24,85.88 169.24,87.81 164.92,87.81 164.57,87.45 164.57,83.39 164.06,82.88 162.38,82.88 161.77,82.27
UNNAMED_18_CN5P6SHLD_I111_N11 on TOP (solid shape): 181.89,96.27 180.72,96.27 180.72,97.51 181.89,97.51
UNNAMED_18_CN5P6SHLD_I111_N11 on TOP: 179.58,100.33 189.23,100.33 189.23,96.27 186.44,96.27 186.44,96.29 186.51,96.37 186.51,97.92 182.25,97.92 182.25,96.27 179.58,96.27

## Text on the board
Ref Des/Silkscreen Bottom: SECONDARY SIDE | 08-080095 REV C Z
User.Comments: 4.    INSTALL P/N: SNT-BK-T ON JP15~JP20 (PIN1 AND PIN2)
Ref Des/Silkscreen Top: AD-BMSE2E3W-SL COMP BOARD | PRIMARY SIDE | 08-080095 REV C Z
PAGE_OUTLINE: TEST PROCESS | FAB NOTES REVISION: 2ND NOVEMBER 2022 | N/A | 8.   IMPEDANCE REQUIREMENTS: IF NO STACKUP IS DEFINED, THE VENDOR IS ALLOWED TO ADJUST THE DIELECTRIC | 13.  PLATING SPECIFICATION: | 1.   DIMENSIONS ARE IN INCHES (EXCEPT WHERE NOTED). | ALL DOCUMENTS & SPECIFICATIONS REFERRED TO BELOW SHOULD BE THE LATEST REVISIONS. | 2.  BOARD MATERIAL:(USE CHECKED ITEMS) | 3.   ALL LAMINATES & BONDING MATERIALS SHOULD BE SELECTED FROM IPC-4101 OR IPC-4103,(TG>170 DEGC TD>300 DEGC) | 4.   REFER TO IPC-6010 SERIES, CLASS 2 FOR FABRICATION. | 5.   REFER TO LAMINATION DIAGRAM FOR OVERALL BOARD THICKNESS, TOLERANCE APPLIES AFTER ALL LAMINATION AND PLATING | 7.   ACCEPTABILITY PER ADI SPECIFICATION TST00115. | 9.   FILLET OPTIONS TO ENHANCE RELIABILITY AT PAD JUNCTIONS WHERE SPACING PERMITS. | 10.  THIEVING: | 11.  LAYER TO LAYER REGISTRATION SHALL BE WITHIN 0.003 INCHES. | 12.  DRILL SIZES ARE FINISHED HOLE SIZES. ALL HOLES SHALL BE LOCATED WITHIN 0.005 INCHES DTP,UNLESS SPECIFIED. | 14.  SURFACE FINISH: | 15.  SOLDERMASK: | 16.  APPLY SILKSCREEN TO BOTH SIDES USING A NON-CONDUCTIVE, EPOXY BASED INK PER ARTWORK. | (X) WHITE | ( ) OTHER | PROCESSES. FINISHED THICKNESS MEASURED FROM TOP COPPER TO BOTTOM COPPER. | (X) ISOLA 370HR OR S1000-2 OR IT180 OR EQUIVALENT | ( ) ISOLA FR408HR OR EQUIVALENT | ( ) ISOLA IS410 | ( ) MEGTRON 6 | ( ) NELCO 4000-13 | ( ) ROGERS 4350B | ( ) ROGERS 3003 | ( ) ARLON 85N | ( ) EM370D | ( ) OTHER ________________________ | ( ) FILLETS ALLOWED | (X) FILLETS NOT ALLOWED | ( ) VENDOR MAY ADD THIEVING TO COMPENSATE FOR LOW COPPER DENSITY AREAS MAINTAINING A MINIMUM | ( ) VENDOR MAY NOT ADD THIEVING TO COMPENSATE FOR LOW COPPER DENSITY AREAS. | (X) LPI | ( ) OTHER_________ | COLOR | ( ) GREEN | (X) OTHER________ | HINDER PROPER SOLDER WICKING. BARREL RELIEF ON SOLDERMASK ALLOWED IN UNFILLED VIA IN PAD HOLES. | (X) REFER TO LAMINATION DIAGRAM FOR FINISHED COPPER WEIGHT/THICKNESS REQUIRMENTS | (X) IMMERSION GOLD (ENIG) 1.58-3.94 MICRO INCHES OVER 118-236 MICRO INCHES MIN. OF ELECTROLESS NICKEL PER IPC-4552 | ( ) OSP (ORGANIC SOLDERABILITY PRESERVATIVE) | ( ) IMMERSION SILVER | ( ) SOFT WIRE BONDABLE GOLD 30-50 MICRO INCHES OF SOFT WIRE | ( ) EDGE CONNECTOR FINGERS ARE TO BE PLATED WITH 100 MICRO-INCHES(.0001") OF LOW STRESS | THICKNESS & TRACE WIDTHS TO MEET THE IMPEDANCE REQUIREMENT. IF SPECIFIED, THE VENDOR MUST | TRACE WIDTH & SPACING THAT IMPACT THE REQUIREMENTS MUST HAVE WRITTEN APPROVAL FROM ADI. | MINIMUM BARREL PLATING OF 0.001 INCHES. PLATED HOLES SHALL NOT BE ROUGH OR IRREGULAR SO AS TO | SOLDERMASK OVER BARE COPPER OR BARE GOLD (BOTH SIDES) TO MEET IPC-SM-840. | IF PRESENT,DO NOT MODIFY SOLDERMASK DEFINED PADS (MASK OPENINGS LESS THAN COPPER PAD) WITHOUT APPROVAL. | MEET THE REQUIREMENTS LISTED IN THE IMPEDANCE TABLE. ANY ADJUSTMENT MADE TO THE DEFINED STACKUP, | UL FLAMMABILITY RATING 94V-0. BOARD MATERIAL & CONSTRUCTION SHALL MEET THE REQUIREMENTS OF UL796/UL796F. | BONDABLE GOLD OVER 100-150 MICRO INCHES OF NICKEL | NICKEL UNDER 30 MICRO-INCHES (.0003') OF GOLD | 0.100 INCH CLEARANCE FROM ALL COPPER FEATURES, | THE STARTING COPPER WEIGHT/THICKNESS CAN VARY AS LONG AS THE FINISHED COPPER | WEIGHT/THICKNESS IS NOT LESS THAN THE SPECIFIED VALUE. | UNLESS OTHERWISE SPECIFIED | BLUE | HOMOGENOUS MATERIALS IN THIS BOARD SHALL BE COMPLAINT WITH THE EU DIRECTIVE 2002/95/EC | WORKMANSHIP SHALL CONFORM TO IPC-A-600, CLASS 2. | 21.  INTENTIONAL SHORTS: | 17.  FINAL ELECTRICAL TEST TO BE PERFORMED USING PROVIDED IPC-D-356A NETLIST OR ODB++ FORMAT FILE. | 22.  PEMNUTS: | 23.  MANUFACTURER TO ETCH/STAMP WITH PERMANENT NON-CONDUCTIVE INK | ON SECONDARY SIDE UNLESS OTHERWISE SPECIFIED: | 18.  A TIME DOMAIN REFLECTOMETER REPORT (TDR) FOR EACH IMPEDANCE CONTROLLED LAYER & A CERTIFICATE | 19.  IF PRESENT, ALL BLIND/BURIED VIAS WITH AN ASPECT RATIO <1:1 TO BE PLATED SHUT WITH COPPER WHEN | 20.  FOR VIA FILL INFORMATION REFER TO DRILL CHART: | 24. PANELIZATION: | 25.  MINIMUM DESIGN LINE WIDTH IS 0.008 INCH. | 26.  MINIMUM DESIGN LINE SPACING IS 0.0064 INCH. | IS ACCEPTABLE, ALL OTHER INSTANCES MUST BE REPORTED. | IF AN INTENTIONAL SHORT REPORT IS SUPPLIED AND DOES NOT MATCH THE FAB DATA THEN | THE PCB SHALL HAVE A VERIFICATION STAMP. | ( )  NON-CONDUCTIVE EPOXY FILL ALL 0.XXXX INCHES DRILLED VIAS | ( )  COPPER FILL ALL 0.XXXX INCHES DRILLED VIAS | ( ) PEMNUTS TO BE INSTALLED BY FABRICATOR | ( ) PEMNUTS NOT TO BE INSTALLED BY FABRICATOR | ( ) NOT APPLICABLE | USED AS VIA-IN-PAD OR AS A STACKED VIA. BLIND/BURIED VIAS WITH AN ASPECT RATIO >1:1 TO BE FILLED | A. UL CODE-FLAMMABILITY RATING FOR THOSE APPROVED MATERIALS(IF APPLICABLE) | B. DATE CODE | C. LOT NUMBER | D. MANUFACTURER LOGO | BOARDS TO BE SHIPPED IN SINGULATED AFTER FABRICATION PROCESS | SMOOTH EDGES AND FREE FROM BURRS AFTER DEPANELIZATION | CAN'T BE PERFORMED BECAUSE THE TRACE LENGTH IS TOO SHORT ON THE OUTER LAYERS AT THE PIN ESCAPES | ADI APPROVAL IS REQUIRED. | OF COMPLIANCE SHALL BE PROVIDED BY VENDOR AT TIME OF SHIPMENT. INSTANCES WHERE TDR TESTING | WITH NON-CONDUCTIVE EPOXY. | REFERENCE LAYER | L2 | L7 | B | C | ECR-119200 | ECR-120183 | 07MAR24 | 22APR24 | C. ARON | NOTES: | TOOLING: | FINISH: | MATERIAL: | TESTING: | MISCELLANEOUS: | COMP BOARD
BODY_CENTER: LABEL PLACEMENT INFORMATION | HALF SIZE LABELS ARE | AVAILABLE IN THE LIBRARY | PLACE WHEELIE BIN LOGO | TO SUIT THE LAYOUT. | PLACE ROHS COMPLIANT LOGO | TO SUIT THE LAYOUT OR | DELETE IF NOT REQ'D. | PLACE CHINA ROHS COMPLIANT | LOGO TO SUIT THE LAYOUT OR | 1.THE BOARD SIZE CAN BE ADJUSTED TO SUIT THE APPLICATION. | 2.THE MOUNTING HOLES CAN BE MOVED/REMOVED TO SUIT THE APPLICATION. | 3.THE FIDUCIALS CAN BE MOVED TO SUIT THE APPLICATION. | 4.ADJUST THE DIMENSIONS TO SUIT THE APPLICATION. | 5.ADD THE CORRECT LAYER STACKUP ON FAB2 BASED ON THE NO OF LAYERS ON THE PCB. | 6.THE ROHS COMPLIANT AND WHEELIE BIN LOGO'S CAN BE MOVED TO THE DESIRED LOCATION. | HALF SIZE VERSIONS OF THE LABELS ARE AVAILABLE IN THE LIBRARY. | NOTES FOR TEMPLATE USAGE. | GENERIC D-SIZE TEMPLATE BR-067706A
DIMENSION: REF | DIA MAX
User.22: L2 GND | 08-      -07
User.23: L3 SIGNAL | 08-      -08
User.24: L4 POWER | 08-      -09
User.25: L5 POWER | 08-      -10
User.26: L6 SIGNAL | 08-      -11
User.27: L7 GND | 08-      -12
User.45: FIGURE | SIZE | 10.0 | 35.0 | 40.0 | 45.0 | 50.0 | 55.0 | 59.0 | 65.0 | 90.0 | 100.0 | 213.0 | 63.0 | 125.0 | 330.0 | 69.0x63.0 | DRILL CHART: TOP to BOTTOM | FINISHED HOLES IN MILS | PLATED | NON-PLATED | SLOT HOLES: TOP to BOTTOM | QTY | 39 | 5070 | 6 | 16 | 73 | 19 | 38 | 12 | 2 | 4 | 3 | 5293 | TOLERANCE/NOTES | TOTAL HOLES:
