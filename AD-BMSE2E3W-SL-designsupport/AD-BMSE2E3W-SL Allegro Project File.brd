# Allegro board AD-BMSE2E3W-SL Allegro Project File.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
I1BS: length 170.5
  TOP w0.381: R174.2 194.4,12.57 C351.2 195.93,11.49 L6.3 L6.4 202.31,11.43 C348.1 v1(204.18,10.4)
  L3_SIGNAL w0.381: R375.I1N 309.11,55.75 295.91,42.54 295.91,8.38 293.88,6.35 218.82,6.35 218.19,6.98 218.19,11.94 217.68,12.45 205.11,12.45 204.18,11.52 v1(204.18,10.4)
I2A: length 10.6
  TOP w0.203: R325.2 191.05,15.64 190.84,15.44 187.19,15.44 186.78,15.85 C356.2 184.96,16.38 184.19,15.62 U5.7
I2AS: length 179.9
  TOP w0.381: v1(209.18,15.63) R376.1 207.52,14.83 207.14,14.45 205.11,14.45 204.05,15.51 C354.1 203.86,15.81 L5.2 L5.1 195.81,15.81 C350.1 195.03,16.38 v1(194.69,16.38) R325.1 ; v1(194.69,19.56) 194.06,20.19 R329.1
  L6_SIGNAL w0.381: v1(209.18,15.63) 215.63,15.63 225.17,6.1 294,6.1 297.69,9.78 297.69,44.58 302.01,48.89 319.66,48.89 321.12,47.44 R375.I2P ; v1(194.69,19.56) v1(194.69,16.38)
I2B: length 11.1
  TOP w0.203: R176.1 191.05,17.64 190.75,17.34 187.19,17.34 186.78,17.75 C345.2 186.29,18.29 184.12,16.12 U5.8
I2BS: length 179.5
  TOP w0.381: R176.2 194.73,18.29 C350.2 195.81,17.21 L5.4 197.61,17.27 200.03,17.27 200.41,16.89 201.93,16.89 L5.3 203.86,17.21 C346.1 204.05,18.33 205,19.28 207.06,19.28 207.44,19.66 R182.1 v1(208.55,20.61)
  L6_SIGNAL w0.381: v1(208.55,20.61) 208.84,20.32 212.09,20.32 225.68,6.73 293.75,6.73 296.8,9.78 296.8,46.99 301.5,51.69 317.05,51.69 R375.I2N
I3A: length 12.5
  TOP w0.203: R326.2 191.05,8.04 190.75,7.75 187.2,7.75 187.03,7.91 C355.2 186.56,8.76 183.95,11.38 183.95,12.14 183.47,12.62 U5.1
I3AS: length 37.5
  TOP w0.381: C349.1 195.68,20.89 L4.1 L4.2 203.73,20.89 C353.2 203.92,20.15 v1(203.2,19.43) ; v1(208.61,17.45) 207.63,17.45 R376.2
  TOP w0.508: R326.1 v1(193.98,8.76)
  L3_SIGNAL w0.381: v1(203.2,19.43) 205.18,17.45 v1(208.61,17.45)
  L6_SIGNAL w0.508: v1(193.98,8.76) 201.14,8.76 201.93,9.55 201.93,18.16 v1(203.2,19.43)
I3B: length 12.5
  TOP w0.203: U5.11 183.22,17.62 185.42,19.81 185.42,21.21 186.31,22.1 C344.2 186.78,21.56 187.19,21.15 190.12,21.15 191.05,22.08 R175.1
I3BS: length 17.5
  TOP w0.381: R175.2 192.91,22.26 C349.2 197.4,22.26 L4.4 L4.3 203.86,22.29 C347.2 203.92,23.23 204.75,24.05 207.06,24.05 207.44,23.67 R182.2
LINKP_IN: length 1.9
  BOTTOM w0.203: D65.C 243.1,93.45 v1(242.57,93.98)
  vias: v1(215.9,67.31) v1(217.17,100.33) v1(217.17,99.06) v1(217.17,97.79) v1(217.17,92.71) v1(217.17,91.44) v1(217.17,90.17) v1(217.17,88.9) v1(217.17,87.63) v1(217.17,86.36) v1(217.17,85.09) v1(217.17,83.82) v1(217.17,82.55) v1(217.17,81.28) v1(217.17,80.01) v1(217.17,78.74) v1(217.17,77.47) v1(217.17,76.2) v1(217.17,74.93) v1(217.17,73.66) v1(217.17,72.39) v1(217.17,71.12) v1(217.17,69.85) v1(217.17,68.58) v1(217.17,67.31) v1(217.17,66.04) v1(217.17,64.77) v1(217.17,63.5) v1(217.17,62.23) v1(217.81,57.78) v1(218.44,100.33) v1(218.44,99.06) v1(218.44,97.79) v1(218.44,92.71) v1(218.44,91.44) v1(218.44,90.17) v1(218.44,88.9) v1(218.44,87.63) v1(218.44,86.36) v1(218.44,85.09) v1(218.44,83.82) v1(218.44,82.55) v1(218.44,81.28) v1(218.44,80.01) v1(218.44,78.74) v1(218.44,77.47) v1(218.44,76.2) v1(218.44,74.93) v1(218.44,73.66) v1(218.44,72.39) v1(218.44,71.12) v1(218.44,69.85) v1(218.44,68.58) v1(218.44,67.31) v1(218.44,66.04) v1(218.44,64.77) v1(218.44,63.5) v1(218.44,62.23) v1(219.08,57.15) v1(219.71,100.33) v1(219.71,99.06) v1(219.71,97.79) v1(219.71,92.71) v1(219.71,91.44) v1(219.71,90.17) v1(219.71,88.9) v1(219.71,87.63) v1(219.71,86.36) v1(219.71,85.09) v1(219.71,83.82) v1(219.71,82.55) v1(219.71,81.28) v1(219.71,80.01) v1(219.71,78.74) v1(219.71,77.47) v1(219.71,76.2) v1(219.71,74.93) v1(219.71,73.66) v1(219.71,72.39) v1(219.71,71.12) v1(219.71,69.85) v1(219.71,68.58) v1(219.71,67.31) v1(219.71,66.04) v1(219.71,64.77) v1(219.71,63.5) v1(219.71,62.23) v1(219.71,60.96) v1(219.71,59.69) v1(219.71,58.42) v1(220.98,100.33) v1(220.98,99.06) v1(220.98,97.79) v1(220.98,92.71) v1(220.98,91.44) v1(220.98,90.17) v1(220.98,88.9) v1(220.98,87.63) v1(220.98,86.36) v1(220.98,85.09) v1(220.98,83.82) v1(220.98,82.55) v1(220.98,81.28) v1(220.98,80.01) v1(220.98,78.74) v1(220.98,77.47) v1(220.98,76.2) v1(220.98,74.93) v1(220.98,73.66) v1(220.98,72.39) v1(220.98,71.12) v1(220.98,69.85) v1(220.98,68.58) v1(220.98,67.31) v1(220.98,66.04) v1(220.98,64.77) v1(220.98,63.5) v1(220.98,62.23) v1(220.98,60.96) v1(220.98,59.69) v1(220.98,58.42) v1(222.12,51.43) v1(222.12,50.16) v1(222.12,48.89) v1(222.12,47.62) v1(222.25,100.33) v1(222.25,99.06) v1(222.25,97.79) v1(222.25,91.44) v1(222.25,90.17) v1(222.25,88.9) v1(222.25,87.63) v1(222.25,86.36) v1(222.25,85.09) v1(222.25,83.82) v1(222.25,82.55) v1(222.25,81.28) v1(222.25,80.01) v1(222.25,78.74) v1(222.25,77.47) v1(222.25,76.2) v1(222.25,74.93) v1(222.25,73.66) v1(222.25,72.39) v1(222.25,71.12) v1(222.25,69.85) v1(222.25,68.58) v1(222.25,67.31) v1(222.25,66.04) v1(222.25,64.77) v1(222.25,63.5) v1(222.25,62.23) v1(222.25,60.96) v1(222.25,59.69) v1(222.25,58.42) v1(223.39,51.43) v1(223.39,50.16) v1(223.39,48.89) v1(223.39,47.62) v1(223.52,100.33) v1(223.52,90.17) v1(223.52,88.9) v1(223.52,87.63) v1(223.52,86.36) v1(223.52,85.09) v1(223.52,82.55) v1(223.52,81.28) v1(223.52,80.01) v1(223.52,78.74) v1(223.52,77.47) v1(223.52,76.2) v1(223.52,74.93) v1(223.52,73.66) v1(223.52,72.39) v1(223.52,71.12) v1(223.52,69.85) v1(223.52,68.58) v1(223.52,67.31) v1(223.52,66.04) v1(223.52,64.77) v1(224.79,100.33) v1(224.79,88.9) v1(224.79,87.63) v1(224.79,86.36) v1(224.79,85.09) v1(224.79,83.82) v1(224.79,82.55) v1(224.79,81.28) v1(224.79,80.01) v1(224.79,78.74) v1(224.79,77.47) v1(224.79,76.2) v1(224.79,74.93) v1(224.79,73.66) v1(224.79,72.39) v1(224.79,71.12) v1(224.79,69.85) v1(224.79,68.58) v1(224.79,67.31) v1(224.79,66.04) v1(224.79,64.77) v1(226.06,100.33) v1(226.06,88.9) v1(226.06,87.63) v1(226.06,86.36) v1(226.06,85.09) v1(226.06,83.82) v1(226.06,82.55) v1(226.06,81.28) v1(226.06,80.01) v1(226.06,78.74) v1(226.06,77.47) v1(226.06,76.2) v1(226.06,74.93) v1(226.06,73.66) v1(226.06,72.39) v1(226.06,71.12) v1(226.06,69.85) v1(226.06,68.58) v1(226.06,67.31) v1(226.06,66.04) v1(226.06,64.77) v1(226.06,63.5) v1(226.06,62.23) v1(226.06,60.96) v1(226.06,59.69) v1(226.06,58.42) v1(226.06,57.15) v1(227.33,100.33) v1(227.33,88.9) v1(227.33,87.63) v1(227.33,86.36) v1(227.33,85.09) v1(227.33,83.82) v1(227.33,82.55) v1(227.33,81.28) v1(227.33,80.01) v1(227.33,78.74) v1(227.33,77.47) v1(227.33,76.2) v1(227.33,74.93) v1(227.33,73.66) v1(227.33,72.39) v1(227.33,71.12) v1(227.33,69.85) v1(227.33,68.58) v1(227.33,67.31) v1(227.33,66.04) v1(227.33,64.77) v1(227.33,63.5) v1(227.33,62.23) v1(227.33,60.96) v1(227.33,59.69) v1(227.33,58.42) v1(227.33,49.53) v1(228.6,100.33) v1(228.6,88.9) v1(228.6,87.63) v1(228.6,86.36) v1(228.6,85.09) v1(228.6,83.82) v1(228.6,82.55) v1(228.6,81.28) v1(228.6,80.01) v1(228.6,78.74) v1(228.6,77.47) v1(228.6,76.2) v1(228.6,74.93) v1(228.6,73.66) v1(228.6,72.39) v1(228.6,71.12) v1(228.6,69.85) v1(228.6,68.58) v1(228.6,67.31) v1(228.6,66.04) v1(228.6,64.77) v1(229.87,100.33) v1(229.87,88.9) v1(229.87,87.63) v1(229.87,86.36) v1(229.87,85.09) v1(229.87,83.82) v1(229.87,82.55) v1(229.87,81.28) v1(229.87,80.01) v1(229.87,78.74) v1(229.87,77.47) v1(229.87,76.2) v1(229.87,74.93) v1(229.87,73.66) v1(229.87,72.39) v1(229.87,71.12) v1(229.87,69.85) v1(229.87,68.58) v1(229.87,67.31) v1(229.87,66.04) v1(229.87,64.77) v1(231.14,100.33) v1(231.14,90.17) v1(231.14,88.9) v1(231.14,87.63) v1(231.14,86.36) v1(231.14,85.09) v1(231.14,83.82) v1(231.14,82.55) v1(231.14,81.28) v1(231.14,80.01) v1(231.14,78.74) v1(231.14,77.47) v1(231.14,76.2) v1(231.14,74.93) v1(231.14,73.66) v1(231.14,72.39) v1(231.14,71.12) v1(231.14,69.85) v1(231.14,68.58) v1(231.14,67.31) v1(231.14,66.04) v1(231.14,64.77) v1(231.14,63.5) v1(231.14,62.23) v1(231.14,59.69) v1(231.14,58.42) v1(231.14,57.15) v1(231.14,55.88) v1(232.41,100.33) v1(232.41,99.06) v1(232.41,90.17) v1(232.41,88.9) v1(232.41,87.63) v1(232.41,86.36) v1(232.41,85.09) v1(232.41,83.82) v1(232.41,82.55) v1(232.41,81.28) v1(232.41,80.01) v1(232.41,78.74) v1(232.41,77.47) v1(232.41,76.2) v1(232.41,74.93) v1(232.41,73.66) v1(232.41,72.39) v1(232.41,71.12) v1(232.41,69.85) v1(232.41,68.58) v1(232.41,67.31) v1(232.41,66.04) v1(232.41,64.77) v1(232.41,63.5) v1(232.41,60.96) v1(232.41,59.69) v1(232.41,58.42) v1(232.41,57.15) v1(232.41,55.88) v1(233.68,100.33) v1(233.68,99.06) v1(233.68,97.79) v1(233.68,96.52) v1(233.68,92.71) v1(233.68,91.44) v1(233.68,90.17) v1(233.68,88.9) v1(233.68,87.63) v1(233.68,86.36) v1(233.68,85.09) v1(233.68,83.82) v1(233.68,82.55) v1(233.68,81.28) v1(233.68,80.01) v1(233.68,78.74) v1(233.68,77.47) v1(233.68,76.2) v1(233.68,74.93) v1(233.68,73.66) v1(233.68,72.39) v1(233.68,71.12) v1(233.68,69.85) v1(233.68,68.58) v1(233.68,67.31) v1(233.68,66.04) v1(233.68,64.77) v1(233.68,62.23) v1(233.68,60.96) v1(233.68,59.69) v1(233.68,58.42) v1(234.95,100.33) v1(234.95,99.06) v1(234.95,97.79) v1(234.95,96.52) v1(234.95,95.25) v1(234.95,93.98) v1(234.95,92.71) v1(234.95,91.44) v1(234.95,90.17) v1(234.95,88.9) v1(234.95,87.63) v1(234.95,86.36) v1(234.95,85.09) v1(234.95,83.82) v1(234.95,82.55) v1(234.95,81.28) v1(234.95,80.01) v1(234.95,78.74) v1(234.95,77.47) v1(234.95,76.2) v1(234.95,74.93) v1(234.95,73.66) v1(234.95,72.39) v1(234.95,71.12) v1(234.95,69.85) v1(234.95,68.58) v1(234.95,67.31) v1(234.95,66.04) v1(234.95,64.77) v1(234.95,62.23) v1(234.95,60.96) v1(234.95,59.69) v1(234.95,58.42) v1(234.95,57.15) v1(234.95,55.88) v1(236.22,100.33) v1(236.22,99.06) v1(236.22,97.79) v1(236.22,96.52) v1(236.22,95.25) v1(236.22,93.98) v1(236.22,92.71) v1(236.22,91.44) v1(236.22,90.17) v1(236.22,88.9) v1(236.22,87.63) v1(236.22,86.36) v1(236.22,85.09) v1(236.22,83.82) v1(236.22,82.55) v1(236.22,81.28) v1(236.22,80.01) v1(236.22,78.74) v1(236.22,77.47) v1(236.22,76.2) v1(236.22,74.93) v1(236.22,73.66) v1(236.22,72.39) v1(236.22,71.12) v1(236.22,69.85) v1(236.22,68.58) v1(236.22,67.31) v1(236.22,66.04) v1(236.22,64.77) v1(236.22,62.23) v1(236.22,60.96) v1(236.22,59.69) v1(236.22,58.42) v1(236.22,57.15) v1(236.22,55.88) v1(237.49,100.33) v1(237.49,99.06) v1(237.49,97.79) v1(237.49,96.52) v1(237.49,95.25) v1(237.49,93.98) v1(237.49,92.71) v1(237.49,91.44) v1(237.49,90.17) v1(237.49,88.9) v1(237.49,87.63) v1(237.49,86.36) v1(237.49,85.09) v1(237.49,83.82) v1(237.49,82.55) v1(237.49,81.28) v1(237.49,80.01) v1(237.49,78.74) v1(237.49,77.47) v1(237.49,76.2) v1(237.49,74.93) v1(237.49,73.66) v1(237.49,72.39) v1(237.49,71.12) v1(237.49,69.85) v1(237.49,68.58) v1(237.49,67.31) v1(237.49,66.04) v1(237.49,64.77) v1(237.49,62.23) v1(237.49,57.15) v1(237.49,55.88) v1(238.76,100.33) v1(238.76,99.06) v1(238.76,97.79) v1(238.76,96.52) v1(238.76,95.25) v1(238.76,93.98) v1(238.76,92.71) v1(238.76,91.44) v1(238.76,90.17) v1(238.76,88.9) v1(238.76,87.63) v1(238.76,86.36) v1(238.76,85.09) v1(238.76,83.82) v1(238.76,82.55) v1(238.76,81.28) v1(238.76,80.01) v1(238.76,78.74) v1(238.76,77.47) v1(238.76,76.2) v1(238.76,74.93) v1(238.76,73.66) v1(238.76,72.39) v1(238.76,71.12) v1(238.76,69.85) v1(238.76,68.58) v1(238.76,67.31) v1(238.76,66.04) v1(238.76,64.77) v1(238.76,62.23) v1(238.76,57.15) v1(238.76,55.88) v1(240.03,100.33) v1(240.03,99.06) v1(240.03,97.79) v1(240.03,96.52) v1(240.03,95.25) v1(240.03,93.98) v1(240.03,92.71) v1(240.03,91.44) v1(240.03,90.17) v1(240.03,88.9) v1(240.03,87.63) v1(240.03,86.36) v1(240.03,85.09) v1(240.03,83.82) v1(240.03,82.55) v1(240.03,81.28) v1(240.03,80.01) v1(240.03,78.74) v1(240.03,77.47) v1(240.03,76.2) v1(240.03,74.93) v1(240.03,73.66) v1(240.03,72.39) v1(240.03,71.12) v1(240.03,69.85) v1(240.03,68.58) v1(240.03,67.31) v1(240.03,66.04) v1(240.03,64.77) v1(240.03,62.23) v1(240.03,60.96) v1(240.03,59.69) v1(240.03,58.42) v1(240.03,57.15) v1(240.03,55.88) v1(241.3,100.33) v1(241.3,99.06) v1(241.3,97.79) v1(241.3,96.52) v1(241.3,95.25) v1(241.3,93.98) v1(241.3,92.71) v1(241.3,91.44) v1(241.3,90.17) v1(241.3,88.9) v1(241.3,87.63) v1(241.3,86.36) v1(241.3,85.09) v1(241.3,83.82) v1(241.3,82.55) v1(241.3,81.28) v1(241.3,80.01) v1(241.3,78.74) v1(241.3,77.47) v1(241.3,76.2) v1(241.3,74.93) v1(241.3,73.66) v1(241.3,72.39) v1(241.3,71.12) v1(241.3,69.85) v1(241.3,68.58) v1(241.3,67.31) v1(241.3,66.04) v1(241.3,64.77) v1(241.3,62.23) v1(241.3,60.96) v1(241.3,59.69) v1(241.3,58.42) v1(241.3,57.15) v1(241.3,55.88) v1(242.57,100.33) v1(242.57,99.06) v1(242.57,97.79) v1(242.57,96.52) v1(242.57,95.25) v1(242.57,90.17) v1(242.57,88.9) v1(242.57,87.63) v1(242.57,86.36) v1(242.57,83.82) v1(242.57,82.55) v1(242.57,81.28) v1(242.57,80.01) v1(242.57,78.74) v1(242.57,77.47) v1(242.57,76.2) v1(242.57,74.93) v1(242.57,73.66) v1(242.57,72.39) v1(242.57,71.12) v1(242.57,66.04) v1(242.57,64.77) v1(242.57,62.23) v1(242.57,60.96) v1(242.57,59.69) v1(242.57,58.42) v1(242.57,57.15) v1(242.57,55.88) v1(243.84,62.23) v1(243.84,60.96) v1(243.84,59.69) v1(243.84,58.42) v1(243.84,57.15) v1(243.84,55.88) v1(245.11,62.23) v1(245.11,60.96) v1(245.11,59.69) v1(245.11,58.42) v1(245.11,57.15) v1(245.11,55.88) v1(246.38,62.23) v1(246.38,60.96) v1(246.38,59.69) v1(246.38,58.42) v1(246.38,57.15) v1(246.38,55.88) v1(247.65,62.23) v1(247.65,60.96) v1(247.65,59.69) v1(247.65,58.42) v1(247.65,57.15) v1(247.65,55.88) v1(248.92,62.23) v1(248.92,60.96) v1(248.92,59.69) v1(248.92,58.42) v1(248.92,57.15) v1(248.92,55.88) v1(250.19,62.23) v1(250.19,60.96) v1(250.19,59.69) v1(250.19,58.42) v1(250.19,57.15) v1(250.19,55.88) v1(251.46,62.23) v1(251.46,60.96) v1(251.46,59.69) v1(251.46,58.42) v1(251.46,57.15) v1(251.46,55.88) v1(252.73,62.23) v1(252.73,60.96) v1(252.73,59.69) v1(252.73,58.42) v1(252.73,57.15) v1(252.73,55.88) v1(254,62.23) v1(254,60.96) v1(254,59.69) v1(254,58.42) v1(254,55.88) v1(255.27,62.23) v1(255.27,60.96) v1(255.27,59.69) v1(255.27,58.42) v1(255.27,57.15) v1(255.27,55.88) v1(256.54,63.5) v1(256.54,62.23) v1(256.54,60.96) v1(256.54,59.69) v1(256.54,58.42) v1(256.54,57.15) v1(256.54,55.88) v1(257.81,63.5) v1(257.81,62.23) v1(257.81,60.96) v1(257.81,59.69) v1(257.81,58.42) v1(257.81,57.15) v1(257.81,55.88) v1(258.44,90.17) v1(258.44,88.9) v1(258.44,87.63) v1(258.44,86.36) v1(258.44,85.09) v1(258.44,83.82) v1(258.44,82.55) v1(258.44,81.28) v1(258.44,80.01) v1(258.44,78.74) v1(258.44,77.47) v1(258.44,76.2) v1(258.44,74.93) v1(258.44,73.66) v1(258.44,72.39) v1(258.44,71.12) v1(258.44,69.85) v1(258.44,68.58) v1(258.44,67.31) v1(258.44,66.04) v1(258.44,64.77) v1(259.08,63.5) v1(259.08,62.23) v1(259.08,60.96) v1(259.08,59.69) v1(259.08,58.42) v1(259.08,57.15) v1(259.08,55.88) v1(259.71,90.17) v1(259.71,88.9) v1(259.71,87.63) v1(259.71,86.36) v1(259.71,85.09) v1(259.71,83.82) v1(259.71,82.55) v1(259.71,81.28) v1(259.71,80.01) v1(259.71,78.74) v1(259.71,77.47) v1(259.71,76.2) v1(259.71,74.93) v1(259.71,73.66) v1(259.71,72.39) v1(259.71,71.12) v1(259.71,69.85) v1(259.71,68.58) v1(259.71,67.31) v1(259.71,66.04) v1(259.71,64.77) v1(260.35,63.5) v1(260.35,62.23) v1(260.35,60.96) v1(260.35,59.69) v1(260.35,58.42) v1(260.35,57.15) v1(260.35,55.88) v1(260.99,90.17) v1(260.99,88.9) v1(260.99,87.63) v1(260.99,86.36) v1(260.99,85.09) v1(260.99,83.82) v1(260.99,82.55) v1(260.99,81.28) v1(260.99,80.01) v1(260.99,78.74) v1(260.99,77.47) v1(260.99,76.2) v1(260.99,74.93) v1(260.99,73.66) v1(260.99,72.39) v1(260.99,71.12) v1(260.99,69.85) v1(260.99,68.58) v1(260.99,67.31) v1(260.99,66.04) v1(260.99,64.77) v1(262.25,90.17) v1(262.25,88.9) v1(262.25,87.63) v1(262.25,86.36) v1(262.25,85.09) v1(262.25,83.82) v1(262.25,82.55) v1(262.25,81.28) v1(262.25,80.01) v1(262.25,78.74) v1(262.25,77.47) v1(262.25,76.2) v1(262.25,74.93) v1(262.25,73.66) v1(262.25,72.39) v1(262.25,71.12) v1(262.25,69.85) v1(262.25,68.58) v1(262.25,67.31) v1(262.25,66.04) v1(262.25,64.77) v1(262.25,63.5) v1(262.25,62.23) v1(262.25,60.96) v1(262.25,59.69) v1(262.25,58.42) v1(262.25,57.15) v1(262.25,55.88) v1(263.53,90.17) v1(263.53,88.9) v1(263.53,87.63) v1(263.53,86.36) v1(263.53,85.09) v1(263.53,83.82) v1(263.53,82.55) v1(263.53,81.28) v1(263.53,80.01) v1(263.53,78.74) v1(263.53,77.47) v1(263.53,76.2) v1(263.53,74.93) v1(263.53,73.66) v1(263.53,72.39) v1(263.53,71.12) v1(263.53,69.85) v1(263.53,68.58) v1(263.53,67.31) v1(263.53,66.04) v1(263.53,64.77) v1(263.53,63.5) v1(263.53,62.23) v1(263.53,60.96) v1(263.53,59.69) v1(263.53,58.42) v1(263.53,57.15) v1(263.53,55.88) v1(264.8,90.17) v1(264.8,88.9) v1(264.8,87.63) v1(264.8,86.36) v1(264.8,85.09) v1(264.8,83.82) v1(264.8,82.55) v1(264.8,81.28) v1(264.8,80.01) v1(264.8,78.74) v1(264.8,77.47) v1(264.8,76.2) v1(264.8,74.93) v1(264.8,73.66) v1(264.8,72.39) v1(264.8,71.12) v1(264.8,69.85) v1(264.8,68.58) v1(264.8,67.31) v1(264.8,66.04) v1(264.8,64.77) v1(264.8,63.5) v1(264.8,62.23) v1(264.8,60.96) v1(264.8,59.69) v1(264.8,58.42) v1(264.8,57.15) v1(264.8,55.88) v1(266.06,90.17) v1(266.06,88.9) v1(266.06,87.63) v1(266.06,86.36) v1(266.06,85.09) v1(266.06,83.82) v1(266.06,82.55) v1(266.06,81.28) v1(266.06,80.01) v1(266.06,78.74) v1(266.06,77.47) v1(266.06,76.2) v1(266.06,74.93) v1(266.06,73.66) v1(266.06,72.39) v1(266.06,71.12) v1(266.06,69.85) v1(266.06,68.58) v1(266.06,67.31) v1(266.06,66.04) v1(266.06,64.77) v1(266.06,63.5) v1(266.06,62.23) v1(266.06,60.96) v1(266.06,59.69) v1(266.06,58.42) v1(266.06,57.15) v1(266.06,55.88) v1(267.34,90.17) v1(267.34,88.9) v1(267.34,87.63) v1(267.34,86.36) v1(267.34,85.09) v1(267.34,83.82) v1(267.34,82.55) v1(267.34,81.28) v1(267.34,80.01) v1(267.34,78.74) v1(267.34,77.47) v1(267.34,76.2) v1(267.34,74.93) v1(267.34,73.66) v1(267.34,72.39) v1(267.34,71.12) v1(267.34,69.85) v1(267.34,68.58) v1(267.34,67.31) v1(267.34,66.04) v1(267.34,64.77) v1(267.34,63.5) v1(267.34,62.23) v1(267.34,60.96) v1(267.34,59.69) v1(267.34,58.42) v1(267.34,57.15) v1(267.34,55.88) v1(268.61,90.17) v1(268.61,88.9) v1(268.61,87.63) v1(268.61,86.36) v1(268.61,85.09) v1(268.61,83.82) v1(268.61,82.55) v1(268.61,81.28) v1(268.61,80.01) v1(268.61,78.74) v1(268.61,77.47) v1(268.61,76.2) v1(268.61,74.93) v1(268.61,73.66) v1(268.61,72.39) v1(268.61,71.12) v1(268.61,69.85) v1(268.61,68.58) v1(268.61,67.31) v1(268.61,66.04) v1(268.61,64.77) v1(268.61,63.5) v1(268.61,62.23) v1(268.61,60.96) v1(268.61,59.69) v1(268.61,58.42) v1(268.61,57.15) v1(268.61,55.88) v1(269.88,90.17) v1(269.88,88.9) v1(269.88,87.63) v1(269.88,86.36) v1(269.88,83.82) v1(269.88,82.55) v1(269.88,78.74) v1(269.88,77.47) v1(269.88,76.2) v1(269.88,74.93) v1(269.88,73.66) v1(269.88,72.39) v1(269.88,71.12) v1(269.88,69.85) v1(269.88,68.58) v1(269.88,67.31) v1(269.88,66.04) v1(269.88,64.77) v1(269.88,63.5) v1(269.88,62.23) v1(269.88,60.96) v1(269.88,59.69) v1(269.88,58.42) v1(269.88,57.15) v1(269.88,55.88) v1(271.15,90.17) v1(271.15,88.9) v1(271.15,87.63) v1(271.15,83.82) v1(271.15,82.55) v1(271.15,78.74) v1(271.15,77.47) v1(271.15,76.2) v1(271.15,74.93) v1(271.15,73.66) v1(271.15,72.39) v1(271.15,71.12) v1(271.15,69.85) v1(271.15,68.58) v1(271.15,67.31) v1(271.15,66.04) v1(271.15,64.77) v1(271.15,63.5) v1(271.15,62.23) v1(271.15,60.96) v1(271.15,59.69) v1(271.15,55.88)
LINKP_OUT: length 11
  TOP w0.254: U11.8 222.71,31.55 223.06,31.19 C234.2
  L3_SIGNAL w0.381: 245.22,72.9 245.27,72.95 245.27,80.12
  vias: v1(223.52,27.94) v1(223.52,26.67) v1(223.52,25.4) v1(223.52,24.13) v1(223.52,22.86) v1(224.79,26.67) v1(224.79,25.4) v1(224.79,24.13) v1(224.79,22.86) v1(226.06,26.67) v1(226.06,25.4) v1(226.06,24.13) v1(226.06,22.86) v1(227.33,26.67) v1(227.33,25.4) v1(227.33,24.13) v1(227.33,22.86) v1(228.6,26.67) v1(228.6,25.4) v1(228.6,24.13) v1(228.6,22.86) v1(229.87,26.67) v1(229.87,25.4) v1(229.87,24.13) v1(229.87,22.86) v1(231.14,49.53) v1(231.14,48.26) v1(231.14,46.99) v1(231.14,45.72) v1(231.14,44.45) v1(231.14,43.18) v1(231.14,41.91) v1(231.14,40.64) v1(231.14,39.37) v1(231.14,38.1) v1(231.14,36.83) v1(231.14,35.56) v1(231.14,34.29) v1(231.14,33.02) v1(231.14,31.75) v1(231.14,30.48) v1(231.14,29.21) v1(231.14,27.94) v1(231.14,26.67) v1(231.14,25.4) v1(231.14,24.13) v1(231.14,22.86) v1(232.41,50.8) v1(232.41,49.53) v1(232.41,48.26) v1(232.41,46.99) v1(232.41,45.72) v1(232.41,44.45) v1(232.41,43.18) v1(232.41,41.91) v1(232.41,40.64) v1(232.41,39.37) v1(232.41,38.1) v1(232.41,36.83) v1(232.41,35.56) v1(232.41,34.29) v1(232.41,33.02) v1(232.41,31.75) v1(232.41,30.48) v1(232.41,29.21) v1(232.41,27.94) v1(232.41,26.67) v1(232.41,25.4) v1(232.41,24.13) v1(232.41,22.86) v1(233.68,50.8) v1(233.68,49.53) v1(233.68,48.26) v1(233.68,46.99) v1(233.68,45.72) v1(233.68,44.45) v1(233.68,43.18) v1(233.68,41.91) v1(233.68,40.64) v1(233.68,39.37) v1(233.68,38.1) v1(233.68,36.83) v1(233.68,35.56) v1(233.68,34.29) v1(233.68,33.02) v1(233.68,31.75) v1(233.68,30.48) v1(233.68,29.21) v1(233.68,27.94) v1(233.68,26.67) v1(233.68,25.4) v1(233.68,24.13) v1(233.68,22.86) v1(234.95,50.8) v1(234.95,49.53) v1(234.95,48.26) v1(234.95,46.99) v1(234.95,45.72) v1(234.95,44.45) v1(234.95,43.18) v1(234.95,41.91) v1(234.95,40.64) v1(234.95,39.37) v1(234.95,38.1) v1(234.95,36.83) v1(234.95,35.56) v1(234.95,34.29) v1(234.95,33.02) v1(234.95,31.75) v1(234.95,30.48) v1(234.95,29.21) v1(234.95,27.94) v1(234.95,26.67) v1(234.95,25.4) v1(234.95,24.13) v1(234.95,22.86) v1(236.22,50.8) v1(236.22,49.53) v1(237.49,50.8) v1(237.49,49.53) v1(238.76,50.8) v1(238.76,49.53) v1(240.03,50.8) v1(240.03,49.53) v1(241.3,50.8) v1(241.3,49.53) v1(242.57,50.8) v1(242.57,49.53) v1(243.84,50.8) v1(243.84,49.53) v1(245.11,50.8) v1(245.11,49.53) v1(245.75,100.33) v1(245.75,99.06) v1(245.75,96.52) v1(245.75,95.25) v1(245.75,90.81) v1(245.75,89.53) v1(245.75,88.26) v1(245.75,87) v1(245.75,83.19) v1(245.75,81.91) v1(245.75,78.74) v1(245.75,77.47) v1(245.75,76.2) v1(245.75,74.93) v1(245.75,73.66) v1(246.38,50.8) v1(246.38,49.53) v1(247.02,100.33) v1(247.02,99.06) v1(247.02,96.52) v1(247.02,88.26) v1(247.02,87) v1(247.02,83.19) v1(247.02,81.91) v1(247.02,78.74) v1(247.02,77.47) v1(247.02,76.2) v1(247.02,74.93) v1(247.02,73.66) v1(247.65,50.8) v1(247.65,49.53) v1(248.29,100.33) v1(248.29,99.06) v1(248.29,96.52) v1(248.29,95.25) v1(248.29,83.19) v1(248.29,81.91) v1(248.29,78.74) v1(248.29,77.47) v1(248.29,76.2) v1(248.29,74.93) v1(248.29,73.66) v1(248.92,50.8) v1(248.92,49.53) v1(249.56,100.33) v1(249.56,99.06) v1(249.56,96.52) v1(249.56,95.25) v1(249.56,90.81) v1(249.56,89.53) v1(249.56,88.26) v1(249.56,87) v1(249.56,83.19) v1(249.56,81.91) v1(249.56,78.74) v1(249.56,77.47) v1(249.56,76.2) v1(249.56,74.93) v1(249.56,73.66) v1(249.56,70.49) v1(249.56,69.21) v1(250.19,50.8) v1(250.19,49.53) v1(250.83,100.33) v1(250.83,99.06) v1(250.83,96.52) v1(250.83,95.25) v1(250.83,90.81) v1(250.83,89.53) v1(250.83,88.26) v1(250.83,87) v1(250.83,83.19) v1(250.83,81.91) v1(250.83,78.74) v1(250.83,77.47) v1(250.83,76.2) v1(250.83,74.93) v1(250.83,73.66) v1(250.83,70.49) v1(250.83,69.21) v1(251.46,50.8) v1(251.46,49.53) v1(252.1,100.33) v1(252.1,99.06) v1(252.1,97.79) v1(252.1,96.52) v1(252.1,95.25) v1(252.1,90.81) v1(252.1,89.53) v1(252.1,88.26) v1(252.1,87) v1(252.1,83.19) v1(252.1,81.91) v1(252.1,80.64) v1(252.1,78.74) v1(252.1,77.47) v1(252.1,76.2) v1(252.1,74.93) v1(252.1,73.66) v1(252.1,72.39) v1(252.1,70.49) v1(252.1,69.21) v1(252.73,50.8) v1(252.73,49.53) v1(253.37,100.33) v1(253.37,99.06) v1(253.37,97.79) v1(253.37,96.52) v1(253.37,95.25) v1(253.37,90.81) v1(253.37,89.53) v1(253.37,88.26) v1(253.37,87) v1(253.37,83.19) v1(253.37,81.91) v1(253.37,80.64) v1(253.37,78.74) v1(253.37,77.47) v1(253.37,76.2) v1(253.37,74.93) v1(253.37,73.66) v1(253.37,72.39) v1(253.37,70.49) v1(253.37,69.21) v1(254,50.8) v1(254,49.53) v1(254.64,100.33) v1(254.64,99.06) v1(254.64,97.79) v1(254.64,96.52) v1(254.64,95.25) v1(255.27,50.8) v1(255.27,49.53) v1(255.91,100.33) v1(255.91,99.06) v1(255.91,97.79) v1(255.91,96.52) v1(255.91,95.25) v1(256.54,50.8) v1(256.54,49.53) v1(257.18,100.33) v1(257.18,99.06) v1(257.18,97.79) v1(257.18,96.52) v1(257.18,95.25) v1(257.81,50.8) v1(257.81,49.53) v1(257.81,48.26) v1(257.81,46.99) v1(257.81,43.18) v1(257.81,41.91) v1(257.81,38.1) v1(257.81,36.83) v1(257.81,35.56) v1(257.81,34.29) v1(257.81,31.11) v1(257.81,29.84) v1(257.81,26.67) v1(257.81,25.4) v1(257.81,24.13) v1(257.81,22.86) v1(257.81,21.59) v1(258.44,100.33) v1(258.44,99.06) v1(258.44,97.79) v1(258.44,96.52) v1(258.44,95.25) v1(259.08,50.8) v1(259.08,49.53) v1(259.08,48.26) v1(259.08,46.99) v1(259.08,43.18) v1(259.08,38.1) v1(259.08,36.83) v1(259.08,35.56) v1(259.08,34.29) v1(259.08,31.11) v1(259.08,29.84) v1(259.08,26.67) v1(259.08,25.4) v1(259.08,24.13) v1(259.08,22.86) v1(259.08,21.59) v1(259.71,100.33) v1(259.71,99.06) v1(259.71,97.79) v1(259.71,96.52) v1(259.71,95.25) v1(260.35,50.8) v1(260.35,49.53) v1(260.35,48.26) v1(260.35,46.99) v1(260.35,43.18) v1(260.35,41.91) v1(260.35,38.1) v1(260.35,36.83) v1(260.35,35.56) v1(260.35,34.29) v1(260.35,31.11) v1(260.35,29.84) v1(260.35,26.67) v1(260.35,25.4) v1(260.35,24.13) v1(260.35,22.86) v1(260.35,21.59) v1(260.99,100.33) v1(260.99,99.06) v1(260.99,97.79) v1(260.99,96.52) v1(260.99,95.25) v1(261.62,50.8) v1(261.62,49.53) v1(261.62,48.26) v1(261.62,46.99) v1(261.62,43.18) v1(261.62,41.91) v1(261.62,38.1) v1(261.62,36.83) v1(261.62,35.56) v1(261.62,34.29) v1(261.62,31.11) v1(261.62,29.84) v1(261.62,26.67) v1(261.62,25.4) v1(261.62,24.13) v1(261.62,22.86) v1(261.62,21.59) v1(262.25,100.33) v1(262.25,99.06) v1(262.25,97.79) v1(262.25,96.52) v1(262.25,95.25) v1(262.89,50.8) v1(262.89,49.53) v1(262.89,48.26) v1(262.89,46.99) v1(262.89,43.18) v1(262.89,38.1) v1(262.89,36.83) v1(262.89,35.56) v1(262.89,34.29) v1(262.89,31.11) v1(262.89,29.84) v1(262.89,26.67) v1(262.89,25.4) v1(262.89,24.13) v1(262.89,22.86) v1(262.89,21.59) v1(262.89,20.32) v1(262.89,19.05) v1(263.53,100.33) v1(263.53,99.06) v1(263.53,97.79) v1(263.53,96.52) v1(263.53,95.25) v1(264.16,50.8) v1(264.16,49.53) v1(264.16,48.26) v1(264.16,46.99) v1(264.16,45.72) v1(264.16,41.91) v1(264.16,36.83) v1(264.16,35.56) v1(264.16,34.29) v1(264.16,29.84) v1(264.16,27.94) v1(264.16,26.67) v1(264.16,25.4) v1(264.16,24.13) v1(264.16,22.86) v1(264.16,21.59) v1(264.8,100.33) v1(264.8,99.06) v1(264.8,97.79) v1(264.8,96.52) v1(264.8,95.25) v1(265.43,50.8) v1(265.43,49.53) v1(265.43,48.26) v1(265.43,46.99) v1(265.43,45.72) v1(265.43,41.91) v1(265.43,25.4) v1(265.43,24.13) v1(265.43,22.86) v1(265.43,21.59) v1(266.06,100.33) v1(266.06,99.06) v1(266.06,97.79) v1(266.06,96.52) v1(266.06,95.25) v1(267.34,100.33) v1(267.34,99.06) v1(267.34,97.79) v1(267.34,96.52) v1(267.34,95.25) v1(267.34,27.94) v1(267.34,26.67) v1(267.34,25.4) v1(267.34,24.13) v1(267.34,22.86) v1(267.34,21.59) v1(267.34,20.32) v1(267.34,19.05) v1(268.61,100.33) v1(268.61,99.06) v1(268.61,97.79) v1(268.61,96.52) v1(268.61,95.25) v1(269.24,50.8) v1(269.24,49.53) v1(269.24,48.26) v1(269.24,46.99) v1(269.88,100.33) v1(269.88,99.06) v1(269.88,97.79) v1(269.88,96.52) v1(269.88,95.25) v1(270.51,50.8) v1(270.51,49.53) v1(270.51,48.26) v1(270.51,46.99) v1(271.15,100.33) v1(271.15,99.06) v1(271.15,97.79) v1(271.15,96.52) v1(271.15,95.25) v1(271.78,50.8) v1(271.78,49.53) v1(271.78,48.26) v1(271.78,46.99) v1(272.42,100.33) v1(272.42,99.06) v1(272.42,97.79) v1(272.42,96.52) v1(272.42,95.25) v1(273.05,50.8) v1(273.05,49.53) v1(273.05,48.26) v1(273.05,46.99) v1(273.69,100.33) v1(273.69,99.06) v1(273.69,97.79) v1(273.69,96.52) v1(273.69,95.25) v1(273.69,78.74) v1(273.69,77.47) v1(273.69,73.66) v1(273.69,72.39) v1(273.69,68.58) v1(273.69,67.31) v1(273.69,66.04) v1(273.69,64.77) v1(273.69,60.96) v1(273.69,59.69) v1(274.32,55.88) v1(274.32,54.61) v1(274.32,50.8) v1(274.32,49.53) v1(274.32,48.26) v1(274.32,46.99) v1(274.96,73.66) v1(274.96,72.39) v1(274.96,68.58) v1(274.96,67.31) v1(274.96,66.04) v1(274.96,64.77) v1(274.96,60.96) v1(274.96,59.69) v1(275.59,55.88) v1(275.59,54.61) v1(275.59,50.8) v1(275.59,49.53) v1(275.59,48.26) v1(275.59,46.99) v1(276.23,81.28) v1(276.23,80.01) v1(276.23,73.66) v1(276.23,72.39) v1(276.23,68.58) v1(276.23,67.31) v1(276.23,66.04) v1(276.23,64.77) v1(276.23,60.96) v1(276.23,59.69) v1(276.86,86.36) v1(276.86,55.88) v1(276.86,54.61) v1(276.86,50.8) v1(276.86,49.53) v1(276.86,48.26) v1(276.86,46.99) v1(277.5,81.28) v1(277.5,80.01) v1(277.5,78.74) v1(277.5,77.47) v1(277.5,73.66) v1(277.5,72.39) v1(277.5,68.58) v1(277.5,67.31) v1(277.5,66.04) v1(277.5,64.77) v1(277.5,60.96) v1(277.5,59.69) v1(278.13,86.36) v1(278.13,85.09) v1(278.13,55.88) v1(278.13,54.61) v1(278.13,50.8) v1(278.13,49.53) v1(278.13,48.26) v1(278.13,46.99) v1(278.76,81.28) v1(278.76,80.01) v1(278.76,78.74) v1(278.76,77.47) v1(278.76,73.66) v1(278.76,72.39) v1(278.76,71.12) v1(278.76,69.85) v1(278.76,68.58) v1(278.76,67.31) v1(278.76,66.04) v1(278.76,64.77) v1(278.76,63.5) v1(278.76,62.23) v1(278.76,60.96) v1(278.76,59.69) v1(279.4,95.63) v1(279.4,86.36) v1(279.4,85.09) v1(279.4,55.88) v1(279.4,54.61) v1(279.4,50.8) v1(279.4,49.53) v1(279.4,48.26) v1(279.4,46.99) v1(280.04,81.28) v1(280.04,80.01) v1(280.04,78.74) v1(280.04,77.47) v1(280.04,73.66) v1(280.04,72.39) v1(280.04,71.12) v1(280.04,69.85) v1(280.04,68.58) v1(280.04,67.31) v1(280.04,66.04) v1(280.04,64.77) v1(280.04,63.5) v1(280.04,62.23) v1(280.04,60.96) v1(280.04,59.69) v1(280.67,50.8) v1(280.67,49.53) v1(280.67,48.26) v1(280.67,46.99) v1(281.94,50.8) v1(281.94,49.53) v1(281.94,48.26) v1(281.94,46.99) v1(283.21,91.44) v1(283.21,90.17) v1(283.21,88.9) v1(283.21,87.63) v1(283.21,86.36) v1(283.21,85.09) v1(283.21,55.88) v1(283.21,54.61) v1(283.21,50.8) v1(283.21,49.53) v1(283.21,48.26) v1(283.21,46.99) v1(283.85,100.33) v1(283.85,99.06) v1(284.48,92.71) v1(284.48,91.44) v1(284.48,90.17) v1(284.48,88.9) v1(284.48,87.63) v1(284.48,86.36) v1(284.48,85.09) v1(284.48,83.82) v1(284.48,82.55) v1(284.48,81.28) v1(284.48,80.01) v1(284.48,78.74) v1(284.48,77.47) v1(284.48,76.2) v1(284.48,74.93) v1(284.48,73.66) v1(284.48,72.39) v1(284.48,71.12) v1(284.48,69.85) v1(284.48,68.58) v1(284.48,67.31) v1(284.48,66.04) v1(284.48,64.77) v1(284.48,63.5) v1(284.48,62.23) v1(284.48,60.96) v1(284.48,59.69) v1(284.48,58.42) v1(284.48,57.15) v1(284.48,55.88) v1(284.48,54.61) v1(284.48,50.8) v1(284.48,49.53) v1(284.48,48.26) v1(284.48,46.99) v1(284.48,44.45) v1(284.48,43.18) v1(284.48,38.73) v1(284.48,37.46) v1(284.48,33.65) v1(284.48,32.38) v1(284.48,31.11) v1(284.48,29.84) v1(284.48,25.4) v1(284.48,24.13) v1(284.48,20.95) v1(284.48,19.68) v1(284.48,18.41) v1(284.48,17.14) v1(284.48,15.88) v1(284.48,12.06) v1(284.48,10.79) v1(285.12,100.33) v1(285.12,99.06) v1(285.12,97.79) v1(285.12,93.98) v1(285.75,92.71) v1(285.75,91.44) v1(285.75,90.17) v1(285.75,88.9) v1(285.75,87.63) v1(285.75,86.36) v1(285.75,85.09) v1(285.75,83.82) v1(285.75,82.55) v1(285.75,81.28) v1(285.75,80.01) v1(285.75,78.74) v1(285.75,77.47) v1(285.75,76.2) v1(285.75,74.93) v1(285.75,73.66) v1(285.75,72.39) v1(285.75,71.12) v1(285.75,69.85) v1(285.75,68.58) v1(285.75,67.31) v1(285.75,66.04) v1(285.75,64.77) v1(285.75,63.5) v1(285.75,62.23) v1(285.75,60.96) v1(285.75,59.69) v1(285.75,58.42) v1(285.75,57.15) v1(285.75,55.88) v1(285.75,54.61) v1(285.75,53.34) v1(285.75,49.53) v1(285.75,48.26) v1(285.75,46.99) v1(285.75,44.45) v1(285.75,43.18) v1(285.75,38.73) v1(285.75,37.46) v1(285.75,33.65) v1(285.75,32.38) v1(285.75,31.11) v1(285.75,29.84) v1(285.75,25.4) v1(285.75,24.13) v1(285.75,20.95) v1(285.75,19.68) v1(285.75,18.41) v1(285.75,17.14) v1(285.75,15.88) v1(285.75,12.06) v1(285.75,10.79) v1(286.38,100.33) v1(286.38,99.06) v1(287.02,92.71) v1(287.02,91.44) v1(287.02,90.17) v1(287.02,88.9) v1(287.02,87.63) v1(287.02,86.36) v1(287.02,85.09) v1(287.02,83.82) v1(287.02,82.55) v1(287.02,81.28) v1(287.02,80.01) v1(287.02,78.74) v1(287.02,77.47) v1(287.02,76.2) v1(287.02,74.93) v1(287.02,73.66) v1(287.02,72.39) v1(287.02,71.12) v1(287.02,69.85) v1(287.02,68.58) v1(287.02,67.31) v1(287.02,66.04) v1(287.02,64.77) v1(287.02,63.5) v1(287.02,59.69) v1(287.02,58.42) v1(287.02,57.15) v1(287.02,55.88) v1(287.02,54.61) v1(287.02,53.34) v1(287.02,52.07) v1(287.02,44.45) v1(287.02,43.18) v1(287.02,38.73) v1(287.02,37.46) v1(287.02,33.65) v1(287.02,32.38) v1(287.02,31.11) v1(287.02,29.84) v1(287.02,25.4) v1(287.02,24.13) v1(287.02,20.95) v1(287.02,19.68) v1(287.02,18.41) v1(287.02,17.14) v1(287.02,15.88) v1(287.02,12.06) v1(287.02,10.79) v1(287.66,100.33) v1(287.66,99.06) v1(288.29,92.71) v1(288.29,91.44) v1(288.29,90.17) v1(288.29,88.9) v1(288.29,87.63) v1(288.29,86.36) v1(288.29,85.09) v1(288.29,83.82) v1(288.29,82.55) v1(288.29,81.28) v1(288.29,80.01) v1(288.29,78.74) v1(288.29,77.47) v1(288.29,76.2) v1(288.29,74.93) v1(288.29,73.66) v1(288.29,72.39) v1(288.29,71.12) v1(288.29,69.85) v1(288.29,68.58) v1(288.29,67.31) v1(288.29,66.04) v1(288.29,64.77) v1(288.29,63.5) v1(288.29,59.69) v1(288.29,58.42) v1(288.29,57.15) v1(288.29,55.88) v1(288.29,54.61) v1(288.29,53.34) v1(288.29,52.07) v1(288.29,44.45) v1(288.29,43.18) v1(288.29,38.73) v1(288.29,37.46) v1(288.29,33.65) v1(288.29,32.38) v1(288.29,31.11) v1(288.29,29.84) v1(288.29,25.4) v1(288.29,24.13) v1(288.29,22.86) v1(288.29,20.95) v1(288.29,19.68) v1(288.29,18.41) v1(288.29,17.14) v1(288.29,15.88) v1(288.29,14.6) v1(288.29,13.33) v1(288.29,12.06) v1(288.29,10.79) v1(288.93,100.33) v1(288.93,99.06) v1(288.93,97.79) v1(288.93,93.98) v1(289.56,66.04) v1(289.56,64.77) v1(289.56,63.5) v1(289.56,59.69) v1(289.56,58.42) v1(289.56,57.15) v1(289.56,55.88) v1(289.56,54.61) v1(289.56,53.34) v1(289.56,52.07) v1(289.56,50.8) v1(289.56,49.53) v1(290.19,100.33) v1(290.19,99.06) v1(290.19,97.79) v1(290.19,96.52) v1(290.19,95.25) v1(290.19,93.98) v1(290.19,92.71) v1(290.83,59.69) v1(290.83,58.42) v1(290.83,57.15) v1(290.83,55.88) v1(290.83,54.61) v1(290.83,53.34) v1(290.83,52.07) v1(290.83,50.8) v1(290.83,49.53) v1(290.83,48.26) v1(291.47,100.33) v1(291.47,99.06) v1(291.47,97.79) v1(291.47,96.52) v1(291.47,95.25) v1(291.47,93.98) v1(291.47,92.71) v1(291.47,91.44) v1(291.47,90.17) v1(291.47,88.9) v1(291.47,87.63) v1(291.47,86.36) v1(291.47,85.09) v1(291.47,83.82) v1(291.47,82.55) v1(291.47,81.28) v1(291.47,80.01) v1(291.47,78.74) v1(291.47,77.47) v1(291.47,76.2) v1(291.47,74.93) v1(291.47,73.66) v1(291.47,72.39) v1(291.47,71.12) v1(291.47,69.85) v1(291.47,68.58) v1(291.47,67.31) v1(291.47,66.04) v1(291.47,64.77) v1(291.47,63.5) v1(292.1,62.23) v1(292.1,60.96) v1(292.1,59.69) v1(292.1,58.42) v1(292.1,57.15) v1(292.1,55.88) v1(292.1,54.61) v1(292.1,53.34) v1(292.1,52.07) v1(292.1,50.8) v1(292.1,49.53) v1(292.1,48.26) v1(292.1,46.99) v1(292.1,45.72) v1(292.1,44.45) v1(292.1,43.18) v1(292.1,41.91) v1(292.1,40.64) v1(292.1,39.37) v1(292.1,38.1) v1(292.1,31.75) v1(292.1,30.48) v1(292.1,29.21) v1(292.1,23.49) v1(292.1,22.22) v1(292.1,20.95) v1(292.1,19.68) v1(292.1,18.41) v1(292.1,16.51) v1(292.1,15.24) v1(292.1,13.97)
LPUART_RX: length 21.5
  TOP w0.203: R220.1 196.85,80.11 198.09,81.36 203.84,81.36 205,80.19 209.37,80.19 209.83,79.73 209.83,78.56 TP15.1
LPUART_TX: length 4.8
  TOP w0.203: R219.2 195.19,75.3 194.06,74.17 193.55,74.17 193.22,73.84 U22.40
MCU_32KIN: length 5.3
  TOP w0.203: C292.2 188.6,74.76 Y1.1 188.51,74.5 188.85,74.17 189.1,74.17 190.42,72.85 U22.47
MCU_32KOUT: length 6.2
  TOP w0.203: C294.2 187.33,74.76 Y1.2 187.41,74.09 187.96,73.53 189.17,73.53 190.02,72.68 U22.48
MCU_CAN0B_RX: length 19
  TOP w0.203: U22.34 196.75,71.02 v1(197.1,71.37) ; v1(202.67,85.7) 202.27,86.09 U19.4
  L6_SIGNAL w0.203: v1(202.67,85.7) 198.4,81.43 198.4,72.47 197.31,71.37 v1(197.1,71.37)
MCU_CAN0B_TX: length 15.2
  TOP w0.203: R314.2 200.38,82.17 v1(200.33,82.12) ; v1(198.09,71.35) 197.36,70.62 U22.33
  L6_SIGNAL w0.203: v1(200.33,82.12) 199.01,80.8 199.01,72.21 198.35,71.55 198.3,71.55 v1(198.09,71.35)
MCU_HFX_OUT: length 7.4
  TOP w0.203: Y2.3 182.43,67.78 C295.2 182.72,67.76 183.58,68.62 U22.58
MCU_HFXIN: length 10
  TOP w0.203: C293.2 180.32,68.88 Y2.1 180.32,69.52 180.52,69.72 183.06,69.72 183.76,69.02 U22.57
MCU_INTR1: length 26.8
  TOP w0.203: U10.7 195.98,49.07 195.39,49.66 v1(193.04,49.66) ; U22.7 191.22,61.94 v1(190.75,61.47)
  L6_SIGNAL w0.203: v1(193.04,49.66) 191.77,49.66 190.5,50.93 189.15,50.93 185.42,54.66 185.42,59.31 187.58,61.47 v1(190.75,61.47)
MCU_INTR2: length 24.4
  TOP w0.203: v1(190.88,60.71) 191.62,61.45 U22.8 ; U10.31 200.13,47.58 200.79,48.23 200.79,50.06 v1(200.23,50.62)
  L6_SIGNAL w0.203: v1(200.23,50.62) 197.89,52.96 193.01,52.96 191.59,54.38 191.59,59.99 v1(190.88,60.71)
MCU_OC1: length 27.6
  TOP w0.203: U22.23 199.07,66.62 v1(199.82,65.86) ; U8.7 v1(207.47,48.06) 207.85,48.44 R199.2
  L6_SIGNAL w0.203: v1(199.82,65.86) 207.47,58.22 v1(207.47,48.06)
MCU_OC2: length 32.3
  TOP w0.203: U22.32 197.98,70.22 v1(198.37,70.61) ; U8.6 208.74,47.4 v1(209.5,48.16) R200.2
  L6_SIGNAL w0.203: v1(198.37,70.61) 198.37,68.71 209.5,57.58 v1(209.5,48.16)
MCU_RSTN: length 49.3
  TOP w0.203: U22.59 184.68,68.22 v1(184.28,67.82) ; P12.10 169.04,93.68 168.83,93.47 167.74,93.47 v1(167.72,93.5)
  TOP w0.254: S1.1 167.71,93.49 v1(167.72,93.5)
  L6_SIGNAL w0.254: v1(184.28,67.82) 183.62,68.48 183.62,75.82 178.33,81.1 178.33,94.01 177.47,94.87 168.78,94.87 167.72,93.8 v1(167.72,93.5)
MCU_SPI1A_CS0: length 9.4
  TOP w0.203: U10.5 196.98,49.75 v1(196.46,50.28) 196.37,50.28 R224.2 ; R332.1 196.96,56.41 v1(196.96,54.61)
  BOTTOM w0.203: v1(196.46,50.28) 196.63,50.45 196.63,54.28 v1(196.96,54.61)
MCU_SPI1A_CS1: length 36.6
  TOP w0.203: v1(203.02,49.86) 203,49.83 203,48.75 R225.2 200.82,46.58 U10.29 ; R335.1 v1(179.49,57.12)
  BOTTOM w0.203: v1(179.49,57.12) 182.39,54.23 195,54.23 196.42,55.65
  BOTTOM w0.254: v1(203.02,49.86) 203.02,53.11 200.48,55.65 196.42,55.65
MCU_SPI1A_MISO: length 26
  TOP w0.203: R336.1 v1(186.31,55.58) ; v1(198.2,50.52) 197.98,50.31 U10.3 ; v1(201.26,45.21) 200.89,45.58 U10.27
  L6_SIGNAL w0.203: v1(198.2,50.52) 197.26,50.52 196.34,51.43 189.74,51.43 186.31,54.86 v1(186.31,55.58)
  BOTTOM w0.254: v1(198.2,50.52) 198.2,49.96 201.78,46.38 201.78,45.72 v1(201.26,45.21)
MCU_SPI1A_MOSI: length 27.9
  TOP w0.203: U10.2 198.48,49.64 199.21,50.37 v1(199.21,50.47) ; v1(200.79,44.63) 200.79,44.68 200.39,45.08 U10.26 ; R333.1 v1(189.36,55.5)
  L6_SIGNAL w0.203: v1(189.36,55.5) 189.36,55.24 192.15,52.45 197.59,52.45 199.21,50.83 v1(199.21,50.47)
  BOTTOM w0.254: v1(200.79,44.63) 200.99,44.42 201.57,44.42 202.23,45.08 202.23,50.37 201.3,51.31 199.47,51.31 199.21,51.05 v1(199.21,50.47)
MCU_SPI1A_SCK: length 23.5
  TOP w0.203: v1(197.48,51.33) U10.4 ; R334.1 v1(187.83,55.04) ; U10.28 199.62,46.08 v1(201.17,46.08)
  L6_SIGNAL w0.203: v1(187.83,55.04) 190.93,51.94 196.87,51.94 v1(197.48,51.33)
  BOTTOM w0.254: v1(197.48,51.33) 197.48,49.76 v1(201.17,46.08)
MCU_USB_DM: length 42.6
  TOP w0.203: 184.96,89.69 185.96,89.69 U21.4 ; U22.37 194.42,72.54 194.88,72.99 195.64,72.99 195.85,73.19 v1(195.85,73.41) ; 184.96,91.62 185.99,91.62 U21.6
  TOP w0.254: v1(192.91,87.28) 192.58,87.62 192.58,88.05 192.05,88.57 185.51,88.57 184.96,89.12 184.96,95.58 185.05,95.68 P11.2
  BOTTOM w0.254: v1(195.85,73.41) 196.37,73.93 196.37,74.33 197.79,75.75 197.79,86.44 195.77,88.46 192.83,88.46 192.58,88.2 192.58,87.62 v1(192.91,87.28)
MCU_USB_DP: length 44.5
  TOP w0.203: v1(196.98,73.41) 196.16,72.58 195.05,72.58 194.83,72.37 194.83,72.07 194.82,72.06 U22.36 ; 184.5,89.69 183.5,89.69 U21.3 ; 184.5,91.62 183.47,91.62 U21.1
  TOP w0.254: P11.3 184.4,95.68 184.5,95.58 184.5,88.93 185.32,88.11 191.86,88.11 192.12,87.86 192.12,87.62 v1(191.78,87.28)
  BOTTOM w0.254: v1(196.98,73.41) 196.82,73.56 196.82,74.14 198.25,75.56 198.25,86.63 195.96,88.91 192.64,88.91 192.12,88.39 192.12,87.62 v1(191.78,87.28)
PRECHARGE_FET_INP: length 4.2
  TOP w0.203: v1(219.71,47.62) 219.85,47.77 U12.4
  TOP w0.254: v1(173.36,12.57) 173.61,12.57 174.65,13.62 U5.34
PRECHARGE_IN:
  vias: v1(226.7,16.51) v1(226.7,15.24) v1(226.7,13.97) v1(226.7,12.7) v1(226.7,11.43) v1(226.7,10.16) v1(226.7,8.89) v1(227.97,16.51) v1(227.97,15.24) v1(227.97,13.97) v1(227.97,12.7) v1(227.97,11.43) v1(227.97,10.16) v1(227.97,8.89) v1(229.24,16.51) v1(229.24,15.24) v1(230.51,16.51) v1(230.51,15.24) v1(231.78,16.51) v1(231.78,15.24) v1(231.78,8.89) v1(233.05,16.51) v1(233.05,15.24) v1(233.05,13.97) v1(233.05,12.7) v1(233.05,11.43) v1(233.05,10.16) v1(233.05,8.89) v1(234.32,16.51) v1(234.32,15.24) v1(234.32,13.97) v1(234.32,12.7) v1(234.32,11.43) v1(234.32,10.16) v1(234.32,8.89) v1(235.59,16.51) v1(235.59,15.24) v1(235.59,13.97) v1(235.59,12.7) v1(235.59,11.43) v1(235.59,10.16) v1(236.86,16.51) v1(236.86,15.24) v1(236.86,13.97) v1(236.86,12.7) v1(236.86,11.43) v1(236.86,10.16) v1(238.12,16.51) v1(238.12,15.24) v1(238.12,13.97) v1(238.12,12.7) v1(238.12,11.43) v1(238.12,10.16) v1(239.4,16.51) v1(239.4,15.24) v1(239.4,13.97) v1(239.4,12.7) v1(239.4,11.43) v1(239.4,10.16) v1(240.67,16.51) v1(240.67,15.24) v1(240.67,13.97) v1(240.67,12.7) v1(240.67,11.43) v1(240.67,10.16) v1(241.94,16.51) v1(241.94,15.24) v1(241.94,13.97) v1(241.94,12.7) v1(241.94,11.43) v1(241.94,10.16) v1(243.21,16.51) v1(243.21,15.24) v1(243.21,13.97) v1(243.21,12.7) v1(243.21,11.43) v1(243.21,10.16) v1(244.48,16.51) v1(244.48,15.24) v1(244.48,13.97) v1(244.48,12.7) v1(244.48,11.43) v1(244.48,10.16) v1(245.75,46.99) v1(245.75,45.72) v1(245.75,44.45) v1(245.75,43.18) v1(245.75,41.91) v1(245.75,40.64) v1(245.75,39.37) v1(245.75,38.1) v1(245.75,36.83) v1(245.75,35.56) v1(245.75,34.29) v1(245.75,33.02) v1(245.75,31.75) v1(245.75,30.48) v1(245.75,29.21) v1(245.75,27.94) v1(245.75,26.67) v1(245.75,25.4) v1(245.75,24.13) v1(245.75,22.86) v1(245.75,21.59) v1(245.75,20.32) v1(245.75,19.05) v1(245.75,17.78) v1(245.75,16.51) v1(245.75,15.24) v1(245.75,13.97) v1(245.75,12.7) v1(245.75,11.43) v1(245.75,10.16) v1(247.02,46.99) v1(247.02,45.72) v1(247.02,44.45) v1(247.02,43.18) v1(247.02,41.91) v1(247.02,40.64) v1(247.02,39.37) v1(247.02,38.1) v1(247.02,36.83) v1(247.02,35.56) v1(247.02,34.29) v1(247.02,33.02) v1(247.02,31.75) v1(247.02,30.48) v1(247.02,29.21) v1(247.02,27.94) v1(247.02,26.67) v1(247.02,25.4) v1(247.02,24.13) v1(247.02,22.86) v1(247.02,21.59) v1(247.02,20.32) v1(247.02,19.05) v1(247.02,17.78) v1(247.02,16.51) v1(247.02,15.24) v1(247.02,13.97) v1(247.02,12.7) v1(247.02,11.43) v1(247.02,10.16) v1(248.29,46.99) v1(248.29,45.72) v1(248.29,44.45) v1(248.29,43.18) v1(248.29,41.91) v1(248.29,40.64) v1(248.29,39.37) v1(248.29,38.1) v1(248.29,36.83) v1(248.29,35.56) v1(248.29,34.29) v1(248.29,33.02) v1(248.29,31.75) v1(248.29,30.48) v1(248.29,29.21) v1(248.29,27.94) v1(248.29,26.67) v1(248.29,25.4) v1(248.29,24.13) v1(248.29,22.86) v1(248.29,21.59) v1(248.29,20.32) v1(248.29,19.05) v1(248.29,17.78) v1(248.29,16.51) v1(248.29,15.24) v1(248.29,13.97) v1(248.29,12.7) v1(248.29,11.43) v1(248.29,10.16) v1(249.56,46.99) v1(249.56,45.72) v1(249.56,44.45) v1(249.56,43.18) v1(249.56,41.91) v1(249.56,40.64) v1(249.56,39.37) v1(249.56,38.1) v1(249.56,36.83) v1(249.56,35.56) v1(249.56,34.29) v1(249.56,33.02) v1(249.56,31.75) v1(249.56,30.48) v1(249.56,29.21) v1(249.56,27.94) v1(249.56,26.67) v1(249.56,25.4) v1(249.56,24.13) v1(249.56,22.86) v1(249.56,21.59) v1(249.56,20.32) v1(249.56,19.05) v1(249.56,17.78) v1(249.56,16.51) v1(249.56,15.24) v1(249.56,13.97) v1(249.56,12.7) v1(249.56,11.43) v1(249.56,10.16) v1(250.83,46.99) v1(250.83,45.72) v1(250.83,44.45) v1(250.83,43.18) v1(250.83,41.91) v1(250.83,40.64) v1(250.83,39.37) v1(250.83,38.1) v1(250.83,36.83) v1(250.83,35.56) v1(250.83,34.29) v1(250.83,33.02) v1(250.83,31.75) v1(250.83,30.48) v1(250.83,29.21) v1(250.83,27.94) v1(250.83,26.67) v1(250.83,25.4) v1(250.83,24.13) v1(250.83,22.86) v1(250.83,21.59) v1(250.83,20.32) v1(250.83,19.05) v1(250.83,17.78) v1(250.83,16.51) v1(250.83,15.24) v1(250.83,13.97) v1(250.83,12.7) v1(250.83,11.43) v1(250.83,10.16) v1(252.1,46.99) v1(252.1,45.72) v1(252.1,44.45) v1(252.1,43.18) v1(252.1,41.91) v1(252.1,40.64) v1(252.1,39.37) v1(252.1,38.1) v1(252.1,36.83) v1(252.1,35.56) v1(252.1,34.29) v1(252.1,33.02) v1(252.1,31.75) v1(252.1,30.48) v1(252.1,29.21) v1(252.1,27.94) v1(252.1,26.67) v1(252.1,25.4) v1(252.1,24.13) v1(252.1,22.86) v1(252.1,21.59) v1(252.1,20.32) v1(252.1,19.05) v1(252.1,17.78) v1(252.1,16.51) v1(252.1,15.24) v1(252.1,13.97) v1(252.1,12.7) v1(252.1,11.43) v1(252.1,10.16) v1(253.37,46.99) v1(253.37,45.72) v1(253.37,44.45) v1(253.37,43.18) v1(253.37,41.91) v1(253.37,40.64) v1(253.37,39.37) v1(253.37,38.1) v1(253.37,36.83) v1(253.37,35.56) v1(253.37,34.29) v1(253.37,33.02) v1(253.37,31.75) v1(253.37,30.48) v1(253.37,29.21) v1(253.37,27.94) v1(253.37,26.67) v1(253.37,25.4) v1(253.37,24.13) v1(253.37,22.86) v1(253.37,21.59) v1(253.37,20.32) v1(253.37,19.05) v1(253.37,17.78) v1(253.37,16.51) v1(253.37,15.24) v1(253.37,13.97) v1(253.37,12.7) v1(253.37,11.43) v1(253.37,10.16) v1(254.64,46.99) v1(254.64,45.72) v1(254.64,44.45) v1(254.64,43.18) v1(254.64,41.91) v1(254.64,40.64) v1(254.64,39.37) v1(254.64,38.1) v1(254.64,36.83) v1(254.64,35.56) v1(254.64,34.29) v1(254.64,33.02) v1(254.64,31.75) v1(254.64,30.48) v1(254.64,29.21) v1(254.64,27.94) v1(254.64,26.67) v1(254.64,25.4) v1(254.64,24.13) v1(254.64,22.86) v1(254.64,21.59) v1(254.64,20.32) v1(254.64,19.05) v1(254.64,17.78) v1(254.64,16.51) v1(254.64,15.24) v1(254.64,13.97) v1(254.64,12.7) v1(254.64,11.43) v1(254.64,10.16) v1(255.91,11.43) v1(255.91,10.16) v1(257.18,12.7) v1(257.18,11.43) v1(257.18,10.16) v1(258.44,12.7) v1(258.44,11.43) v1(258.44,10.16) v1(259.71,12.7) v1(259.71,11.43) v1(259.71,10.16) v1(259.71,8.89) v1(260.99,12.7) v1(260.99,11.43) v1(260.99,10.16) v1(260.99,8.89) v1(262.25,12.7) v1(262.25,11.43) v1(262.25,10.16) v1(262.25,8.89) v1(263.53,12.7) v1(263.53,11.43) v1(263.53,10.16) v1(263.53,8.89) v1(264.8,12.7) v1(264.8,11.43) v1(264.8,10.16) v1(264.8,8.89) v1(266.06,12.7) v1(266.06,11.43) v1(266.06,10.16) v1(266.06,8.89) v1(267.34,12.7) v1(267.34,11.43) v1(267.34,10.16) v1(267.34,8.89) v1(268.61,12.7) v1(268.61,11.43) v1(268.61,10.16) v1(268.61,8.89) v1(269.88,12.7) v1(269.88,11.43) v1(269.88,10.16) v1(269.88,8.89) v1(271.15,43.18) v1(271.15,41.91) v1(271.15,40.64) v1(271.15,39.37) v1(271.15,38.1) v1(271.15,36.83) v1(271.15,35.56) v1(271.15,34.29) v1(271.15,33.02) v1(271.15,31.75) v1(271.15,30.48) v1(271.15,29.21) v1(271.15,27.94) v1(271.15,26.67) v1(271.15,25.4) v1(271.15,24.13) v1(271.15,22.86) v1(271.15,21.59) v1(271.15,20.32) v1(271.15,19.05) v1(271.15,17.78) v1(271.15,16.51) v1(271.15,15.24) v1(271.15,13.97) v1(271.15,12.7) v1(271.15,11.43) v1(271.15,10.16) v1(271.15,8.89) v1(272.42,43.18) v1(272.42,41.91) v1(272.42,40.64) v1(272.42,39.37) v1(272.42,38.1) v1(272.42,36.83) v1(272.42,35.56) v1(272.42,34.29) v1(272.42,33.02) v1(272.42,31.75) v1(272.42,30.48) v1(272.42,29.21) v1(272.42,27.94) v1(272.42,26.67) v1(272.42,25.4) v1(272.42,24.13) v1(272.42,22.86) v1(272.42,21.59) v1(272.42,20.32) v1(272.42,19.05) v1(272.42,17.78) v1(272.42,16.51) v1(272.42,15.24) v1(272.42,13.97) v1(272.42,12.7) v1(272.42,11.43) v1(272.42,10.16) v1(272.42,8.89) v1(273.69,43.18) v1(273.69,41.91) v1(273.69,40.64) v1(273.69,39.37) v1(273.69,38.1) v1(273.69,36.83) v1(273.69,35.56) v1(273.69,34.29) v1(273.69,33.02) v1(273.69,31.75) v1(273.69,30.48) v1(273.69,29.21) v1(273.69,27.94) v1(273.69,26.67) v1(273.69,25.4) v1(273.69,24.13) v1(273.69,22.86) v1(273.69,21.59) v1(273.69,20.32) v1(273.69,19.05) v1(273.69,17.78) v1(273.69,16.51) v1(273.69,15.24) v1(273.69,13.97) v1(273.69,12.7) v1(273.69,11.43) v1(273.69,10.16) v1(273.69,8.89) v1(274.96,43.18) v1(274.96,41.91) v1(274.96,40.64) v1(274.96,39.37) v1(274.96,38.1) v1(274.96,36.83) v1(274.96,35.56) v1(274.96,34.29) v1(274.96,33.02) v1(274.96,31.75) v1(274.96,30.48) v1(274.96,29.21) v1(274.96,27.94) v1(274.96,26.67) v1(274.96,25.4) v1(274.96,24.13) v1(274.96,22.86) v1(274.96,21.59) v1(274.96,20.32) v1(274.96,19.05) v1(274.96,17.78) v1(274.96,16.51) v1(274.96,15.24) v1(274.96,13.97) v1(274.96,12.7) v1(274.96,11.43) v1(274.96,10.16) v1(274.96,8.89) v1(276.23,43.18) v1(276.23,41.91) v1(276.23,40.64) v1(276.23,39.37) v1(276.23,38.1) v1(276.23,36.83) v1(276.23,35.56) v1(276.23,34.29) v1(276.23,33.02) v1(276.23,31.75) v1(276.23,30.48) v1(276.23,29.21) v1(276.23,27.94) v1(276.23,26.67) v1(276.23,25.4) v1(276.23,24.13) v1(276.23,22.86) v1(276.23,21.59) v1(276.23,20.32) v1(276.23,19.05) v1(276.23,17.78) v1(276.23,16.51) v1(276.23,15.24) v1(276.23,13.97) v1(276.23,12.7) v1(276.23,11.43) v1(276.23,10.16) v1(276.23,8.89) v1(277.5,43.18) v1(277.5,41.91) v1(277.5,40.64) v1(277.5,39.37) v1(277.5,38.1) v1(277.5,36.83) v1(277.5,35.56) v1(277.5,34.29) v1(277.5,33.02) v1(277.5,31.75) v1(277.5,30.48) v1(277.5,29.21) v1(277.5,27.94) v1(277.5,26.67) v1(277.5,25.4) v1(277.5,24.13) v1(277.5,22.86) v1(277.5,21.59) v1(277.5,20.32) v1(277.5,19.05) v1(277.5,17.78) v1(277.5,16.51) v1(277.5,15.24) v1(277.5,13.97) v1(277.5,12.7) v1(277.5,11.43) v1(277.5,10.16) v1(277.5,8.89) v1(278.76,43.18) v1(278.76,41.91) v1(278.76,40.64) v1(278.76,39.37) v1(278.76,38.1) v1(278.76,36.83) v1(278.76,35.56) v1(278.76,34.29) v1(278.76,33.02) v1(278.76,31.75) v1(278.76,30.48) v1(278.76,29.21) v1(278.76,27.94) v1(278.76,26.67) v1(278.76,25.4) v1(278.76,24.13) v1(278.76,22.86) v1(278.76,21.59) v1(278.76,20.32) v1(278.76,19.05) v1(278.76,17.78) v1(278.76,16.51) v1(278.76,15.24) v1(278.76,13.97) v1(278.76,12.7) v1(278.76,11.43) v1(278.76,10.16) v1(278.76,8.89) v1(280.04,43.18) v1(280.04,41.91) v1(280.04,40.64) v1(280.04,39.37) v1(280.04,38.1) v1(280.04,36.83) v1(280.04,35.56) v1(280.04,34.29) v1(280.04,33.02) v1(280.04,31.75) v1(280.04,30.48) v1(280.04,29.21) v1(280.04,27.94) v1(280.04,26.67) v1(280.04,25.4) v1(280.04,24.13) v1(280.04,22.86) v1(280.04,21.59) v1(280.04,20.32) v1(280.04,19.05) v1(280.04,17.78) v1(280.04,16.51) v1(280.04,15.24) v1(280.04,13.97) v1(280.04,12.7) v1(280.04,11.43) v1(280.04,10.16) v1(280.04,8.89)
S1A: length 10.5
  TOP w0.203: R328.2 191.05,13.74 190.84,13.53 187.19,13.53 186.98,13.74 186.98,14.48 186.91,14.56 ; 186.91,14.56 C359.2 ; 186.91,14.56 186.84,14.62 U5.5
S2A: length 12.4
  TOP w0.203: R329.2 191.05,19.54 190.75,19.25 187.19,19.25 186.78,19.66 C358.2 186.44,20.19 185.55,19.3 185.55,18.12 184.04,16.62 U5.9
SWCLK: length 40
  TOP w0.203: R318.1 v1(172.85,93.34) P12.4 ; U22.61 185.53,67.42 184.21,66.1 v1(184.21,65.65)
  L6_SIGNAL w0.254: v1(172.85,93.34) 176.56,89.64 176.56,80.95 180.57,76.94 180.57,69.29 v1(184.21,65.65)
SWDIO: length 38.7
  TOP w0.203: v1(184.91,65.79) 184.91,66.17 185.76,67.02 U22.62 ; P12.2 174.12,93.7 R317.1 175.41,92.46 v1(176.66,92.46)
  L6_SIGNAL w0.254: v1(184.91,65.79) 181.1,69.6 181.1,77.37 177.27,81.2 177.27,92.2 177.01,92.46 v1(176.66,92.46)
