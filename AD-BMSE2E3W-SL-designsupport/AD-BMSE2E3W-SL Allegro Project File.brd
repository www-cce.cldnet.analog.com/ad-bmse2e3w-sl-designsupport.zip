# Allegro board AD-BMSE2E3W-SL Allegro Project File.brd (continued)
## Nets (continued)
UNNAMED_18_ADMAX32690V2_I1_P3: R371.2(N2) U22.41
UNNAMED_18_ADMAX32690V2_I1_P3_1: R220.2(N2) U22.39
UNNAMED_18_ADMAX32690V2_I1_P4: R372.2(N2) U22.60
UNNAMED_18_ADMAX32690V2_I1_VDDABB: C271.1 C273.1 U22.49 U22.56
UNNAMED_18_ADMAX32690V2_I1_VDDARF: C269.1 C270.1 U22.51 U22.55
UNNAMED_18_ADMAX32690V2_I1_VDDB: C278.1 P21.1 U22.35
UNNAMED_18_ADMAX32690V2_I1_VREF: C286.1 P23.1 R320.1 U22.43
UNNAMED_18_ADMAX32690V2_I1_VREG1: C274.2(N2) U22.46
UNNAMED_18_ADMAX32690V2_I1_VUSB0P9: C272.1 U22.38(VUSB0P9)
UNNAMED_18_CAP_I64_N1: C289.1 C291.1 R324.2(N2) U20.1
UNNAMED_18_CAP_I165_N2: C289.2(N2) P23.2(N2) R322.1 U20.6
UNNAMED_18_CN5P6SHLD_I111_N1: L2.2(N2) P11.1
UNNAMED_18_CN5P6SHLD_I111_N11: L3.2(N2) P11.SH1 P11.SH2 P11.SH3 P11.SH4(N9) P11.SH5 P11.SH6
UNNAMED_18_ICMAX6071_I114_GNDS: R323.2(N2) U20.2
UNNAMED_18_ICMAX6071_I114_OUTS: R322.2(N2) U20.5(OUTS)
UNNAMED_18_NCTESTPAD_I160_N1: R219.1 TP14.1(N1)
UNNAMED_18_RES_I101_N2: R315.2(N2) R316.2(N2) R317.2(N2) R318.2(N2)
V_SENSE1: P7.1 R235.1
V_SENSE2: P7.3 R251.1
V_SENSE3: P7.5 R267.1
V_SENSE4: P7.7 R283.1
V_SENSE5: P7.9(N9) R299.1
V_SENSE6: P8.1 R241.1
V_SENSE7: P8.3 R257.1
V_SENSE8: P8.5 R273.1
V_SENSE9: P8.7 R289.1
V_SENSE10: P8.9(N9) R305.1

Pads without a net: P11 4; P12 7; T1 2 4 5 7 12 13; T2 2 4 5 7 12 13; T3 2 4 5 7 12 13; T4 2 5; T5 2 4 5 7 12 13; U2 1 2 3; U4 1 2 3; U5 41; U6 5 11; U7 1 2 3; U11 10; U12 10; U13 10; U15 6; U19 5

## Via types
v1: diameter 0.508, hole 0.254, TOP to BOTTOM, 5109 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
1V1_VCORE: length 6
  TOP w0.203: v1(189.71,75.97) 191.62,74.06 U22.44
  BOTTOM w0.508: C277.1 189.59,76.1 v1(189.71,75.97)
  vias: v1(204.04,55.7) v1(204.65,55.7)
1V2_VBLE:
  vias: v1(171.6,82.27) v1(171.6,81.61) v1(172.24,82.27) v1(172.24,81.61) v1(204.8,53.52) v1(204.8,52.96)
1V8_VDD: length 22.6
  TOP w0.203: U22.45 191.22,73.8 190.09,74.93 v1(189.61,74.93)
  TOP w0.762: R315.1 v1(169.2,92.21)
  L4_POWER w0.762: P18.2 163.25,79.17 165.23,81.15 165.23,88.24 v1(169.2,92.21)
  BOTTOM w0.508: v1(189.61,74.93) 189.19,74.93 C279.1
  vias: v1(203.12,57.84) v1(203.84,57.78)
3V3_LDO: length 5
  TOP w0.203: v1(192.29,75.26) 192.29,75.12 192.42,74.99 U22.42
  BOTTOM w0.508: C276.1 v1(192.29,75.26)
3V3_VDD: length 16.6
  TOP w0.254: v1(194.69,50.29) 195.38,50.29 196.48,49.19 U10.6 ; U10.30 200.52,47.08 201.3,47.85 201.3,48.89 v1(201.55,49.15)
  TOP w0.508: R199.1 R200.1 v1(210.53,50.66) ; R316.1 v1(169.2,88.38) ; v1(195.58,53.8) R224.1 ; C228.1 194.69,50.36 v1(194.69,50.29)
  TOP w0.762: v1(185.14,53.21) 186.92,53.21 187.2,52.93 ; R382.2 182.92,77.22 v1(183.26,77.22)
  BOTTOM w0.508: v1(194.69,50.29) 194.69,49.89 194.91,49.67 C229.1
  vias: v1(167.21,87.15) v1(167.21,86.54) v1(167.18,82.2) v1(167.18,81.59) v1(167.18,77.12) v1(167.18,76.51) v1(187.58,41.12) v1(187.58,40.41) v1(188.29,41.12) v1(188.29,40.41) v1(194.18,85.52) v1(194.77,85.5) v1(203.84,84.76) v1(203.84,84.18) v1(204.14,59.11) v1(204.44,84.76) v1(204.44,84.18) v1(204.7,59.11) v1(204.65,48.34) v1(204.65,47.73) v1(205.31,48.34) v1(205.31,47.73)
GND1: length 14.8
  TOP w0.203: v1(36.7,35.18) 37.85,34.04 D4.1 ; v1(42.29,25.78) 42.04,25.53 C70.2
  TOP w0.254: U1.61 v1(36.59,42.66) ; C69.2 59.4,28.97 60.02,29.59 v1(60.07,29.59) ; 40.64,48.26 40.64,47.75 41.05,47.34 U1.67 ; v1(37.97,40.64) 38.72,40.64 39.55,41.47 U1.64
  vias: v1(1.65,99.95) v1(1.91,93.6) v1(1.91,91.06) v1(1.91,88.52) v1(1.91,85.98) v1(1.91,83.44) v1(1.91,80.9) v1(1.91,78.36) v1(1.91,75.82) v1(1.91,73.79) v1(1.91,71.25) v1(1.91,69.21) v1(1.91,66.68) v1(1.91,64.64) v1(1.91,62.1) v1(1.91,60.07) v1(1.91,57.53) v1(1.91,54.99) v1(1.91,52.45) v1(1.91,49.91) v1(1.91,47.37) v1(1.91,45.34) v1(1.91,42.8) v1(1.91,40.77) v1(1.91,38.23) v1(1.91,36.19) v1(1.91,33.65) v1(1.91,31.62) v1(1.91,29.08) v1(1.91,27.05) v1(1.91,24.51) v1(1.91,21.97) v1(1.91,19.43) v1(1.91,17.4) v1(1.91,14.86) v1(1.91,12.83) v1(1.91,10.29) v1(3.18,75.82) v1(3.18,31.62) v1(3.18,29.08) v1(3.18,27.05) v1(3.18,24.51) v1(3.18,21.97) v1(3.18,19.43) v1(3.18,17.4) v1(3.18,14.86) v1(3.18,12.83) v1(3.18,10.29) v1(3.43,85.98) v1(3.43,83.44) v1(3.43,80.9) v1(3.43,78.36) v1(4.7,36.19) v1(4.7,34.42) v1(4.95,85.98) v1(4.95,83.44) v1(4.95,80.9) v1(4.95,78.36) v1(4.95,8) v1(5.97,35.18) v1(5.97,33.4) v1(6.22,85.98) v1(6.22,83.44) v1(6.22,80.9) v1(6.22,26.54) v1(6.22,24.76) v1(6.22,22.99) v1(6.22,21.21) v1(6.22,19.43) v1(6.22,17.65) v1(6.99,44.83) v1(6.99,43.05) v1(6.99,41.27) v1(6.99,39.75) v1(6.99,38.48) v1(7.24,35.94) v1(7.24,34.16) v1(7.49,85.98) v1(7.49,83.44) v1(7.49,2.67) v1(7.75,53.97) v1(7.75,52.2) v1(7.75,50.42) v1(7.75,48.64) v1(8,26.54) v1(8,24.76) v1(8,22.99) v1(8,21.21) v1(8,19.43) v1(8,17.65) v1(8.26,99.69) v1(8.26,98.68) v1(8.26,97.66) v1(8.26,32.38) v1(8.26,30.61) v1(8.51,44.83) v1(8.51,43.05) v1(8.51,41.27) v1(8.51,39.75) v1(8.51,38.48) v1(8.76,85.98) v1(8.76,83.44) v1(8.76,53.97) v1(8.76,52.2) v1(8.76,50.42) v1(8.76,48.89) v1(8.76,47.62) v1(9.02,8) v1(9.78,72.01) v1(9.78,70.23) v1(9.78,68.71) v1(9.78,66.93) v1(9.78,65.4) v1(9.78,63.63) v1(9.78,61.85) v1(9.78,60.07) v1(9.78,58.29) v1(9.78,56.51) v1(10.03,99.69) v1(10.03,98.68) v1(10.03,97.66) v1(10.03,2.16) v1(10.49,21.21) v1(10.49,19.28) v1(10.54,85.98) v1(10.54,31.11) v1(10.54,29.34) v1(10.54,26.8) v1(10.54,25.02) v1(10.54,24) v1(10.54,22.22) v1(10.54,20.19) v1(10.54,18.41) v1(10.79,66.17) v1(10.79,64.39) v1(10.79,62.61) v1(10.79,61.85) v1(10.79,60.83) v1(10.79,59.06) v1(10.79,57.28) v1(11.05,73.28) v1(11.05,71.5) v1(11.05,69.47) v1(11.05,67.69) v1(12.07,99.69) v1(12.07,98.68) v1(12.07,97.66) v1(12.07,96.65) v1(12.57,8.25) v1(12.83,2.16) v1(14.35,73.79) v1(14.35,72.01) v1(14.35,70.23) v1(14.35,67.94) v1(14.61,99.69) v1(14.61,98.68) v1(14.61,43.69) v1(15.11,2.16) v1(15.32,17.65) v1(15.37,66.17) v1(15.37,61.85) v1(15.37,60.07) v1(15.37,57.53) v1(15.37,55.5) v1(15.37,51.69) v1(15.37,50.42) v1(15.37,49.15) v1(15.37,48.08) v1(15.37,46.61) v1(15.37,44.32) v1(15.37,42.04) v1(15.37,41.02) v1(15.37,40) v1(15.37,35.18) v1(15.37,33.4) v1(15.37,31.37) v1(15.37,29.59) v1(15.37,27.81) v1(15.42,25.88) v1(15.37,24.26) v1(15.62,75.01) v1(15.62,73.79) v1(15.62,72.01) v1(15.62,70.23) v1(15.62,67.94) v1(15.62,8.25) v1(16.89,67.94) v1(17.14,93.09) v1(17.14,91.57) v1(17.14,89.53) v1(17.65,94.62) v1(17.65,72.52) v1(18.16,77.34) v1(18.16,2.16) v1(18.67,95.38) v1(18.67,72.52) v1(18.92,78.61) v1(18.92,13.84) v1(18.92,12.57) v1(18.92,11.3) v1(18.92,9.78) v1(18.92,8.51) v1(19.68,77.34) v1(19.68,72.52) v1(19.94,24) v1(19.94,22.73) v1(19.94,19.94) v1(19.94,18.41) v1(20.19,67.94) v1(20.19,62.87) v1(20.45,89.03) v1(20.45,79.88) v1(20.45,78.61) v1(20.45,13.84) v1(20.45,12.57) v1(20.45,11.3) v1(20.45,9.78) v1(20.45,8.51) v1(20.45,3.68) v1(20.45,2.16) v1(21.21,77.34) v1(21.46,95.38) v1(21.46,93.85) v1(21.46,92.58) v1(21.46,91.31) v1(21.46,86.49) v1(21.46,19.94) v1(21.46,18.41) v1(21.72,62.87) v1(21.97,79.88) v1(21.97,78.61) v1(21.97,66.17) v1(22.23,87.5) v1(22.23,31.37) v1(22.23,29.59) v1(22.23,28.07) v1(22.23,26.8) v1(22.23,25.53) v1(22.73,3.68) v1(22.73,2.16) v1(22.99,67.94) v1(22.99,34.67) v1(22.99,17.91) v1(23.24,85.22) v1(23.24,79.88) v1(23.24,66.17) v1(23.24,62.87) v1(24,95.38) v1(24,93.85) v1(24,92.58) v1(24,91.31) v1(24.26,80.64) v1(24.61,72.52) v1(24.77,86.49) v1(24.77,35.94) v1(25.02,77.34) v1(25.02,66.17) v1(25.02,33.91) v1(25.27,83.44) v1(25.53,3.68) v1(25.53,2.16) v1(25.78,87.5) v1(25.78,72.52) v1(25.78,34.67) v1(26.04,78.1) v1(26.04,77.34) v1(26.29,95.38) v1(26.29,93.85) v1(26.29,92.58) v1(26.29,91.31) v1(26.8,84.96) v1(26.8,77.34) v1(27.05,78.87) v1(27.81,78.1) v1(27.81,77.34) v1(27.81,3.68) v1(27.81,2.16) v1(28.07,78.87) v1(28.07,33.65) v1(28.32,72.52) v1(28.57,86.74) v1(28.83,95.38) v1(28.83,93.85) v1(28.83,92.58) v1(28.83,91.31) v1(28.83,77.34) v1(28.83,32.13) v1(29.34,34.67) v1(29.64,72.52) v1(29.84,3.68) v1(29.84,2.16) v1(30.48,52.45) v1(30.61,80.64) v1(30.61,79.38) v1(31.11,95.38) v1(31.11,93.85) v1(31.11,92.58) v1(31.11,91.31) v1(31.11,12.06) v1(31.11,10.29) v1(31.11,8.51) v1(31.37,85.98) v1(31.62,80.64) v1(31.62,79.38) v1(31.62,78.36) v1(32.13,83.44) v1(32.13,34.92) v1(32.38,86.74) v1(32.38,34.16) v1(32.89,80.64) v1(32.89,79.38) v1(32.89,78.36) v1(32.89,77.34) v1(33.15,87.5) v1(33.15,85.98) v1(33.15,83.44) v1(33.4,35.69) v1(33.45,72.52) v1(33.66,86.74) v1(33.91,95.38) v1(33.91,93.85) v1(33.91,92.58) v1(33.91,91.31) v1(34.16,87.76) v1(34.16,80.64) v1(34.16,79.38) v1(34.16,78.36) v1(34.16,77.34) v1(34.42,83.44) v1(34.67,85.98) v1(34.67,56.01) v1(34.8,72.52) v1(34.93,86.74) v1(35.31,33.78) v1(35.43,80.64) v1(35.43,79.38) v1(35.43,78.36) v1(35.43,77.34) v1(35.69,83.44) v1(35.69,55.24) v1(35.94,95.38) v1(35.94,93.85) v1(35.94,92.58) v1(35.94,91.31) v1(35.94,34.67) v1(36.45,56.51) v1(36.7,84.45) v1(36.7,80.64) v1(36.7,79.38) v1(36.7,78.36) v1(36.7,77.34) v1(36.96,83.44) v1(36.96,54.99) v1(37.11,72.52) v1(37.21,85.47) v1(37.21,60.32) v1(37.21,56.51) v1(37.72,95.38) v1(37.72,93.85) v1(37.72,92.58) v1(37.72,91.31) v1(37.72,86.49) v1(37.72,84.71) v1(37.97,85.72) v1(37.97,83.44) v1(37.97,80.64) v1(37.97,79.38) v1(37.97,78.36) v1(37.97,77.34) v1(38.43,72.52) v1(38.48,67.94) v1(38.48,29.34) v1(39.24,80.64) v1(39.24,79.38) v1(39.24,78.36) v1(39.24,77.34) v1(39.24,65.91) v1(39.75,95.38) v1(39.75,93.85) v1(39.75,92.58) v1(39.75,91.31) v1(40.51,87.25) v1(40.51,84.45) v1(40.56,72.52) v1(40.77,85.47) v1(41.02,86.49) v1(40.98,51.43) v1(40.98,50.8) v1(40.98,50.16) v1(40.98,49.53) v1(40.98,48.89) v1(40.98,48.26) v1(40.98,47.62) v1(40.98,46.99) v1(41.53,95.38) v1(41.53,93.85) v1(41.53,92.58) v1(41.53,91.31) v1(41.53,84.71) v1(41.53,66.42) v1(41.61,51.43) v1(41.61,50.8) v1(41.61,50.16) v1(41.61,49.53) v1(41.61,48.89) v1(41.61,48.26) v1(41.61,47.62) v1(41.61,46.99) v1(41.78,85.47) v1(41.78,81.41) v1(41.78,80.39) v1(41.78,79.38) v1(41.78,78.36) v1(41.78,77.34) v1(42.04,87.25) v1(42.04,86.49) v1(42.25,51.43) v1(42.25,50.8) v1(42.25,50.16) v1(42.25,49.53) v1(42.25,48.89) v1(42.25,48.26) v1(42.25,47.62) v1(42.25,46.99) v1(42.49,29.13) v1(42.8,77.6) v1(42.8,76.83) v1(42.8,72.52) v1(42.8,31.52) v1(42.88,51.43) v1(42.88,50.8) v1(42.88,50.16) v1(42.88,49.53) v1(42.88,48.89) v1(42.88,48.26) v1(42.88,47.62) v1(42.88,46.99) v1(43.52,51.43) v1(43.52,50.8) v1(43.52,50.16) v1(43.52,49.53) v1(43.52,48.89) v1(43.52,48.26) v1(43.52,47.62) v1(43.52,46.99) v1(43.56,95.38) v1(43.56,93.85) v1(43.56,92.58) v1(43.56,91.31) v1(44.15,51.43) v1(44.15,50.8) v1(44.15,50.16) v1(44.15,49.53) v1(44.15,48.89) v1(44.15,48.26) v1(44.15,47.62) v1(44.15,46.99) v1(44.32,72.52) v1(44.58,87.25) v1(44.58,86.23) v1(44.83,82.17) v1(44.83,80.64) v1(44.83,78.87) v1(44.79,51.43) v1(44.79,50.8) v1(44.79,50.16) v1(44.79,49.53) v1(44.79,48.89) v1(44.79,48.26) v1(44.79,47.62) v1(44.79,46.99) v1(45.34,87.25) v1(45.59,95.38) v1(45.59,93.85) v1(45.59,92.58) v1(45.59,91.31) v1(46.35,83.44) v1(46.35,82.17) v1(46.35,80.64) v1(46.35,78.87) v1(46.35,77.34) v1(46.61,72.77) v1(46.86,84.45) v1(47.37,72.52) v1(47.62,83.44) v1(47.88,95.38) v1(47.88,93.85) v1(47.88,92.58) v1(47.88,91.31) v1(47.88,82.17) v1(47.88,80.64) v1(47.88,78.87) v1(47.88,77.34) v1(48.13,36.45) v1(49.66,86.23) v1(49.66,80.64) v1(49.66,78.87) v1(49.66,77.34) v1(49.66,36.45) v1(49.91,95.38) v1(49.91,93.85) v1(49.91,92.58) v1(49.91,91.31) v1(50.16,84.96) v1(50.93,86.23) v1(51.18,83.95) v1(51.18,80.64) v1(51.18,78.87) v1(51.18,77.34) v1(51.69,84.96) v1(51.69,72.52) v1(51.94,95.38) v1(51.94,93.85) v1(51.94,92.58) v1(51.94,91.31) v1(52.2,86.23) v1(52.45,83.95) v1(52.7,80.64) v1(52.7,78.87) v1(52.7,77.34) v1(53.21,72.52) v1(53.72,95.38) v1(53.72,93.85) v1(53.72,92.58) v1(53.72,91.31) v1(53.98,80.64) v1(53.98,78.87) v1(54.74,85.98) v1(54.99,86.74) v1(54.99,72.52) v1(55.24,85.22) v1(55.75,95.38) v1(55.75,93.85) v1(55.75,92.58) v1(55.75,91.31) v1(56.01,86.74) v1(56.01,85.98) v1(56.01,84.71) v1(56.26,79.38) v1(56.26,78.36) v1(56.52,80.14) v1(56.77,77.34) v1(57.28,79.38) v1(57.53,95.38) v1(57.53,93.85) v1(57.53,92.58) v1(57.53,91.31) v1(57.53,78.36) v1(58.29,77.34) v1(58.39,72.47) v1(58.55,78.36) v1(59.56,95.38) v1(59.56,93.85) v1(59.56,92.58) v1(59.56,91.31) v1(59.56,77.34) v1(60.07,72.52) v1(60.07,63.37) v1(60.07,62.36) v1(60.07,61.34) v1(60.07,60.32) v1(60.07,59.31) v1(60.07,58.04) v1(61.59,95.38) v1(61.59,93.85) v1(61.59,92.58) v1(61.59,91.31) v1(62.1,72.52) v1(62.36,78.36) v1(62.36,63.37) v1(62.36,62.36) v1(62.36,61.34) v1(62.36,60.32) v1(62.36,59.31) v1(62.36,58.04) v1(63.27,72.57) v1(63.37,95.38) v1(63.37,93.85) v1(63.37,92.58) v1(63.37,91.31) v1(63.63,77.34) v1(63.88,78.36) v1(64.74,72.57) v1(65.15,95.38) v1(65.15,93.85) v1(65.15,92.58) v1(65.15,91.31) v1(65.15,78.36) v1(65.15,63.12) v1(65.15,61.34) v1(65.41,87) v1(65.41,85.98) v1(65.41,77.34) v1(65.91,84.96) v1(66.42,87) v1(66.42,85.98) v1(66.67,83.95) v1(66.67,77.34) v1(66.93,78.36) v1(67.18,95.38) v1(67.18,93.85) v1(67.18,92.58) v1(67.18,91.31) v1(67.34,72.57) v1(67.44,85.98) v1(67.44,84.96) v1(67.95,77.34) v1(68.45,83.95) v1(68.96,95.38) v1(68.96,93.85) v1(68.96,92.58) v1(68.96,91.31) v1(69.47,72.52) v1(69.98,75.06) v1(70.23,73.53) v1(70.74,67.18) v1(70.74,65.15) v1(70.74,63.12) v1(70.74,62.2) v1(70.74,60.22) v1(70.74,58.45) v1(70.99,95.38) v1(70.99,93.85) v1(70.99,92.58) v1(70.99,91.31) v1(70.99,75.06) v1(71.25,73.53) v1(71.25,71.75) v1(71.25,70.23) v1(71.25,68.71) v1(73.79,85.98) v1(74.3,74.04) v1(74.3,72.52) v1(74.3,70.99) v1(74.3,69.98) v1(74.3,68.71) v1(75.06,85.22) v1(75.56,45.08) v1(75.56,43.56) v1(75.56,42.29) v1(75.56,40.51) v1(75.82,36.7) v1(75.82,35.69) v1(75.82,34.42) v1(76.07,85.98) v1(76.33,28.07) v1(77.09,46.35) v1(77.09,44.32) v1(77.09,43.05) v1(77.09,41.53) v1(77.09,36.7) v1(77.09,35.69) v1(77.09,34.42) v1(77.34,85.22) v1(77.85,47.62) v1(77.85,45.59) v1(77.85,43.81) v1(77.85,42.29) v1(78.36,85.98) v1(78.36,36.7) v1(78.36,35.69) v1(78.87,31.62) v1(78.87,29.59) v1(78.87,28.07) v1(79.38,39.24) v1(79.38,37.97) v1(79.38,36.7) v1(80.14,40.26) v1(80.14,38.73) v1(80.14,37.21) v1(81.15,31.62) v1(81.15,29.59) v1(81.15,28.07) v1(81.66,88.26) v1(81.66,87) v1(81.66,85.72) v1(81.66,84.2) v1(81.66,82.68) v1(81.66,81.79) v1(81.66,33.91) v1(82.55,77.6) v1(82.55,76.71) v1(82.55,75.69)
GND2: length 67.1
  TOP w0.203: v1(180.59,9.91) 180.59,10.28 179.88,10.99 179.88,11 179.69,11.19 U5.44 ; U13.5 222.3,39.17 222.5,38.97 v1(222.5,38.23) ; C205.2 169.79,15.56 v1(170.21,15.98) ; C170.2 90.07,15.85 v1(89.28,16.64) ; U5.46 U5.47 181.19,11.21 181.36,11.05 v1(182.37,11.05) ; C180.2 v1(85.47,10.54) ; 213.3,14.48 v1(213.3,16.38)
  TOP w0.254: v1(176.09,21.4) 177.69,19.79 U5.21 ; 220.48,37.6 220.98,38.1 U13.3 ; 220.48,37.6 U13.2 ; 220.48,37.6 v1(220.35,37.46) ; U3.64 119.22,40.61 v1(118.49,39.88) ; v1(220.98,46.99) 220.35,47.62 U12.5 ; 218.85,47.79 v1(218.57,47.5) ; 218.85,47.79 219.35,48.29 U12.3 ; 218.85,47.79 U12.2 ; U5.PAD 177.93,15.37 v1(177.8,15.24) ; 188.43,18.29 C345.1 ; U3.61 v1(116.26,42.66) ; C178.2 91.67,10.51 v1(92.49,9.69) ; U11.2 215.94,32.05 215.39,31.5 v1(215.27,31.5) ; U3.67 120.72,47.34 ; C344.1 188.43,22.1 ; 188.43,16.38 C356.1 ; U5.24 174.66,18.76 v1(174.5,18.92) ; U6.6 135.09,6.06 v1(134.62,5.59) ; C358.1 188.43,20.19
  TOP w0.381: v1(189.36,16.38) 188.43,16.38 ; C343.1 189.23,12.57 v1(189.48,12.83) ; 188.43,20.19 v1(189.36,20.19) ; v1(189.36,18.29) 188.43,18.29 ; C355.1 v1(189.61,8.76) ; C357.1 v1(189.48,10.67) ; 188.43,22.1 v1(189.48,22.1) ; C359.1 v1(189.48,14.48)
  TOP w0.508: C186.2 v1(114.43,34.67) ; v1(204.98,10.29) 205.78,11.09 C348.2 C352.2 ; v1(160.1,5.77) 160.05,5.77 159.99,5.71 159.59,5.71 159.21,5.33 U7.7
  TOP w0.762: v1(127.55,40.64) 128.18,40 C161.2 ; v1(149.86,2.92) 149.99,2.79 U7.4
  TOP w1.016: P4.18 P4.19
  L3_SIGNAL w0.762: v1(127.55,40.64) v1(127.55,41.35)
  BOTTOM w0.762: R391.1 216.54,59.31 D67.1
  vias: v1(84.2,33.02) v1(84.2,31.5) v1(84.2,29.97) v1(84.2,28.45) v1(84.2,26.92) v1(84.2,25.4) v1(84.33,95.48) v1(84.33,94.56) v1(84.33,93.75) v1(84.33,92.94) v1(84.33,92.13) v1(84.33,91.31) v1(84.33,90.4) v1(84.33,89.48) v1(84.33,88.47) v1(84.33,87.6) v1(84.33,86.69) v1(84.91,100.05) v1(85.47,33.02) v1(85.47,31.5) v1(85.47,29.97) v1(85.47,28.45) v1(85.47,26.92) v1(85.47,25.4) v1(86.44,100.05) v1(87.25,82.27) v1(87.3,81.2) v1(87.25,80.14) v1(87.5,16.08) v1(88.01,100.05) v1(90.25,21.06) v1(90.4,17.2) v1(90.86,73.28) v1(90.86,72.21) v1(90.88,71.22) v1(90.88,69.95) v1(90.88,68.68) v1(90.88,67.41) v1(95.12,74.8) v1(95.12,73.53) v1(95.12,72.26) v1(95.12,70.99) v1(95.12,69.72) v1(95.12,68.2) v1(95.12,18.67) v1(95.07,16.18) v1(97.05,16.23) v1(97.41,77.34) v1(98.42,78.36) v1(98.93,77.34) v1(99.57,10.92) v1(99.69,64.9) v1(99.95,78.36) v1(100.46,80.39) v1(100.46,79.38) v1(100.97,86.49) v1(100.97,77.34) v1(100.97,62.87) v1(101.47,78.36) v1(101.98,87.5) v1(101.98,80.39) v1(101.98,79.38) v1(102.74,40) v1(103,84.96) v1(103,60.83) v1(103.25,55.35) v1(103.5,80.39) v1(104.01,85.98) v1(105.03,87) v1(105.03,83.44) v1(105.03,77.34) v1(105.54,78.36) v1(106.05,84.45) v1(106.55,79.38) v1(106.55,78.36) v1(106.55,77.34) v1(107.06,85.47) v1(107.31,35.69) v1(107.7,60.83) v1(108.08,86.49) v1(108.08,80.39) v1(108.08,79.38) v1(108.08,78.36) v1(108.08,77.34) v1(108.33,41.02) v1(109.09,87.5) v1(109.09,32.64) v1(110.11,52.45) v1(111.63,83.95) v1(111.63,80.9) v1(111.63,79.38) v1(111.63,78.36) v1(111.89,41.02) v1(112.39,63.63) v1(112.7,34.52) v1(113.16,84.96) v1(113.16,83.95) v1(113.16,80.9) v1(113.16,79.38) v1(113.16,77.34) v1(113.16,33.65) v1(114.55,31.62) v1(114.68,85.98) v1(114.68,84.96) v1(114.68,83.95) v1(114.68,80.9) v1(114.68,79.38) v1(114.68,77.34) v1(115.44,55.24) v1(116.2,87) v1(116.2,85.98) v1(116.2,84.96) v1(116.2,83.95) v1(116.2,80.9) v1(116.2,79.38) v1(116.2,77.34) v1(116.46,33.4) v1(116.71,56.51) v1(117.22,88.01) v1(117.22,12.83) v1(117.22,11.56) v1(117.6,34.54) v1(117.73,87) v1(117.73,85.98) v1(117.73,84.96) v1(117.73,83.95) v1(117.73,80.9) v1(117.73,79.38) v1(117.73,77.34) v1(117.73,40.26) v1(118.49,29.54) v1(118.49,12.83) v1(118.49,11.56) v1(119.25,80.9) v1(119.25,79.38) v1(119.25,77.34) v1(119.76,12.83) v1(119.76,11.56) v1(120.27,88.01) v1(120.27,87) v1(120.27,85.98) v1(120.27,84.96) v1(120.27,83.95) v1(120.65,51.43) v1(120.65,50.8) v1(120.65,50.16) v1(120.65,49.53) v1(120.65,48.89) v1(120.65,48.26) v1(120.65,47.62) v1(120.65,46.99) v1(120.78,12.83) v1(120.78,11.56) v1(121.28,51.43) v1(121.28,50.8) v1(121.28,50.16) v1(121.28,49.53) v1(121.28,48.89) v1(121.28,48.26) v1(121.28,47.62) v1(121.28,46.99) v1(121.79,80.9) v1(121.79,79.38) v1(121.79,78.36) v1(121.79,77.34) v1(121.84,66.42) v1(121.92,51.43) v1(121.92,50.8) v1(121.92,50.16) v1(121.92,49.53) v1(121.92,48.89) v1(121.92,48.26) v1(121.92,47.62) v1(121.92,46.99) v1(122.17,26.8) v1(122.55,51.43) v1(122.55,50.8) v1(122.55,50.16) v1(122.55,49.53) v1(122.55,48.89) v1(122.55,48.26) v1(122.55,47.62) v1(122.55,46.99) v1(122.81,87) v1(122.81,85.98) v1(122.81,84.96) v1(123.19,51.43) v1(123.19,50.8) v1(123.19,50.16) v1(123.19,49.53) v1(123.19,48.89) v1(123.19,48.26) v1(123.19,47.62) v1(123.19,46.99) v1(123.32,78.36) v1(123.32,77.34) v1(123.83,87) v1(123.83,85.98) v1(123.83,84.96) v1(123.83,51.43) v1(123.83,50.8) v1(123.83,50.16) v1(123.83,49.53) v1(123.83,48.89) v1(123.83,48.26) v1(123.83,47.62) v1(123.83,46.99) v1(124.33,81.91) v1(124.33,80.9) v1(124.46,51.43) v1(124.46,50.8) v1(124.46,50.16) v1(124.46,49.53) v1(124.46,48.89) v1(124.46,48.26) v1(124.46,47.62) v1(124.46,46.99) v1(124.84,87) v1(124.84,85.98) v1(125.35,82.93) v1(125.35,81.91) v1(125.35,80.9) v1(125.35,79.88) v1(125.35,15.88) v1(125.35,14.86) v1(126.36,82.93) v1(126.36,81.91) v1(126.36,80.9) v1(126.36,79.88) v1(126.36,78.87) v1(126.36,77.85) v1(126.36,15.88) v1(126.36,14.86) v1(126.92,99.95) v1(126.87,84.45) v1(127.38,82.93) v1(127.38,81.91) v1(127.38,80.9) v1(127.38,79.88) v1(127.38,78.87) v1(127.38,77.85) v1(127.38,15.88) v1(127.38,14.86) v1(127.89,88.01) v1(127.89,35.81) v1(128.3,99.95) v1(128.4,81.91) v1(128.4,80.9) v1(128.4,79.88) v1(128.4,78.87) v1(128.4,77.85) v1(129.41,85.98) v1(129.41,84.96) v1(129.41,80.9) v1(129.41,79.88) v1(129.41,78.87) v1(129.41,77.85) v1(129.54,37.34) v1(129.67,99.95) v1(129.67,98.68) v1(129.67,97.41) v1(130.43,87) v1(130.43,85.98) v1(130.43,84.96) v1(130.43,83.95) v1(130.43,80.9) v1(130.43,79.88) v1(130.43,78.87) v1(130.43,77.85) v1(130.58,65.46) v1(130.94,99.95) v1(130.94,98.68) v1(130.94,97.41) v1(131.32,30.73) v1(131.32,29.84) v1(131.32,28.68) v1(131.32,27.41) v1(131.44,88.01) v1(131.44,80.9) v1(131.44,79.88) v1(131.44,78.87) v1(131.44,77.85) v1(131.95,87) v1(131.95,85.98) v1(131.95,84.96) v1(131.95,83.95) v1(132.21,99.95) v1(132.21,98.68) v1(132.21,97.41) v1(132.33,10.03) v1(132.33,8.76) v1(132.46,80.9) v1(132.46,79.88) v1(132.46,78.87) v1(132.46,77.85) v1(132.46,38.1) v1(132.97,83.44) v1(133.27,9.78) v1(133.27,8.81) v1(133.48,99.95) v1(133.48,98.68) v1(133.48,97.41) v1(133.48,80.9) v1(133.48,79.88) v1(133.73,60.07) v1(134.24,55.5) v1(134.34,9.73) v1(134.34,8.81) v1(134.49,87) v1(134.49,85.98) v1(134.75,99.95) v1(134.75,98.68) v1(134.75,97.41) v1(135,88.01) v1(135.41,9.73) v1(135.41,8.81) v1(135.51,87) v1(135.51,85.98) v1(135.51,84.96) v1(135.51,77.85) v1(135.64,37.34) v1(136.02,99.95) v1(136.02,98.68) v1(136.02,97.41) v1(136.53,79.88) v1(136.53,78.87) v1(136.53,77.85) v1(137.16,6.35) v1(137.29,99.95) v1(137.29,98.68) v1(137.29,97.41) v1(137.54,78.87) v1(137.54,77.85) v1(137.8,35.94) v1(138,40.92) v1(138.05,87) v1(138.05,85.98) v1(138.05,84.96) v1(138.43,4.44) v1(138.56,99.95) v1(138.56,98.68) v1(138.56,97.41) v1(138.56,88.01) v1(138.56,83.95) v1(138.56,77.85) v1(138.56,27.05) v1(139.07,87) v1(139.07,85.98) v1(139.07,84.96) v1(139.32,29.59) v1(139.57,82.93) v1(139.83,99.95) v1(139.83,98.68) v1(139.83,97.41) v1(139.78,45.85) v1(140.59,81.91) v1(141.1,99.95) v1(141.1,98.68) v1(141.1,97.41) v1(141.1,8.25) v1(141.1,6.98) v1(141.22,24) v1(141.61,87) v1(141.61,85.98) v1(141.61,84.96) v1(141.61,80.9) v1(141.61,78.36) v1(141.73,34.8) v1(141.81,53.06) v1(142.11,88.01) v1(142.11,83.95) v1(142.37,99.95) v1(142.37,98.68) v1(142.37,97.41) v1(142.62,87) v1(142.62,85.98) v1(142.62,84.96) v1(142.62,78.36) v1(142.62,77.34) v1(142.62,43.31) v1(142.62,42.29) v1(142.88,34.8) v1(143.13,82.93) v1(143.51,11.94) v1(143.51,10.67) v1(143.64,99.95) v1(143.64,98.68) v1(143.64,97.41) v1(143.64,43.31) v1(143.64,42.29) v1(143.64,41.27) v1(144.15,78.36) v1(144.15,77.34) v1(144.65,43.31) v1(144.65,42.29) v1(144.65,41.27) v1(144.65,40.26) v1(144.91,99.95) v1(144.91,98.68) v1(144.91,97.41) v1(145.01,28.57) v1(144.96,27.71) v1(145.16,87) v1(145.16,85.98) v1(145.16,84.96) v1(145.16,62.23) v1(145.16,45.85) v1(145.67,88.01) v1(145.67,83.95) v1(145.67,78.36) v1(145.67,77.34) v1(145.8,58.8) v1(146.18,99.95) v1(146.18,98.68) v1(146.18,97.41) v1(146.18,87) v1(146.18,85.98) v1(146.18,84.96) v1(147.19,85.98) v1(147.19,84.96) v1(147.19,83.95) v1(147.19,78.36) v1(147.19,77.34) v1(147.45,99.95) v1(147.45,98.68) v1(147.45,97.41) v1(148.21,84.96) v1(148.21,83.95) v1(148.72,99.95) v1(148.72,98.68) v1(148.72,97.41) v1(148.72,77.34) v1(149.1,88.77) v1(149.23,83.95) v1(149.68,77.34) v1(149.73,74.8) v1(149.73,73.28) v1(149.73,71.75) v1(149.73,70.23) v1(149.73,68.71) v1(149.99,99.95) v1(149.99,98.68) v1(149.99,97.41) v1(151.26,99.95) v1(151.26,98.68) v1(151.26,97.41) v1(151.26,74.8) v1(151.26,73.28) v1(151.26,71.75) v1(151.26,70.23) v1(151.26,68.71) v1(152.27,88.01) v1(152.27,86.49) v1(152.53,99.95) v1(152.53,98.68) v1(152.53,97.41) v1(153.8,99.95) v1(153.8,98.68) v1(153.8,97.41) v1(153.8,86.49) v1(153.92,74.8) v1(153.92,73.28) v1(153.92,71.88) v1(153.92,68.83) v1(154.94,55.24) v1(154.94,53.97) v1(154.94,52.7) v1(154.94,51.43) v1(154.94,50.16) v1(155.07,99.95) v1(155.07,98.68) v1(155.07,97.41) v1(155.32,86.49) v1(156.34,99.95) v1(156.34,98.68) v1(156.34,97.41) v1(156.34,88.01) v1(156.34,82.93) v1(156.85,86.49) v1(157.45,39.95) v1(157.48,12.7) v1(157.48,11.43) v1(157.86,92.94) v1(157.86,84.2) v1(157.86,82.93) v1(157.86,81.91) v1(157.86,80.9) v1(157.96,41.94) v1(158.62,85.22) v1(159.13,82.93) v1(159.13,81.91) v1(159.13,80.9) v1(159.13,79.63) v1(159.39,85.98) v1(159.54,100.36) v1(159.64,84.45) v1(159.64,41.94) v1(159.79,96.55) v1(160.4,85.22) v1(160.35,9.73) v1(160.55,38.68) v1(160.76,92.48) v1(160.91,85.98) v1(160.91,41.33) v1(160.91,40.06) v1(161.01,100.36) v1(162.79,26.03) v1(162.94,38.99) v1(163.96,38.99) v1(164.72,25.93) v1(165.02,17.09) v1(165.99,11.35) v1(166.09,46.86) v1(166.5,39.5) v1(168.63,21.41) v1(170.31,18.87) v1(170.66,11.3) v1(170.82,8.51) v1(171.78,25.93) v1(171.83,21.46) v1(172.21,7.62) v1(173.71,25.88) v1(174.75,29.59) v1(174.75,28.57) v1(174.75,8.89) v1(174.75,8) v1(177.17,17.14) v1(177.17,16.51) v1(177.17,15.88) v1(177.17,15.24) v1(177.17,14.6) v1(177.17,13.97) v1(177.17,13.33) v1(177.8,17.14) v1(177.8,16.51) v1(177.8,15.88) v1(177.8,14.6) v1(177.8,13.97) v1(177.8,13.33) v1(178.44,17.14) v1(178.44,16.51) v1(178.44,15.88) v1(178.44,15.24) v1(178.44,14.6) v1(178.44,13.97) v1(178.44,13.33) v1(178.44,8.76) v1(178.82,7.24) v1(179.07,17.14) v1(179.07,16.51) v1(179.07,15.88) v1(179.07,15.24) v1(179.07,14.6) v1(179.07,13.97) v1(179.07,13.33) v1(179.71,17.14) v1(179.71,16.51) v1(179.71,15.88) v1(179.71,15.24) v1(179.71,14.6) v1(179.71,13.97) v1(179.71,13.33) v1(180.34,17.14) v1(180.34,16.51) v1(180.34,15.88) v1(180.34,15.24) v1(180.34,14.6) v1(180.34,13.97) v1(180.34,13.33) v1(180.47,8.25) v1(180.72,25.02) v1(180.98,17.14) v1(180.98,16.51) v1(180.98,15.88) v1(180.98,15.24) v1(180.98,14.6) v1(180.98,13.97) v1(180.98,13.33) v1(181.1,7.37) v1(181.48,30.61) v1(183.26,7.24) v1(183.52,25.27) v1(185.04,25.27) v1(185.14,35.74) v1(186.06,35.74) v1(186.97,35.74) v1(187.88,35.74) v1(188.8,35.74) v1(189.71,35.74) v1(190.63,35.74) v1(191.54,35.74) v1(192.41,27.61) v1(192.46,35.74) v1(193.37,35.74) v1(194.28,35.74) v1(195.2,35.74) v1(195.61,27.61) v1(196.06,35.74) v1(196.98,35.74) v1(197.89,35.74) v1(198.91,35.74) v1(199.82,35.74) v1(200.74,35.74) v1(201.75,35.74) v1(202.36,27.61) v1(202.67,35.74) v1(203.58,35.74) v1(204.7,35.74) v1(204.85,16.48) v1(205.82,27.61) v1(206.68,16.48) v1(209.55,24.13) v1(209.55,18.41) v1(210.82,36.83) v1(212.09,43.81) v1(212.09,42.54) v1(212.09,41.27) v1(212.09,40) v1(213.11,43.81) v1(213.11,42.54) v1(213.11,41.27) v1(213.11,40) v1(216.54,52.96) v1(216.54,51.82) v1(218.19,32) v1(218.19,30.99) v1(218.69,51.69) v1(218.69,50.67) v1(218.67,31.55) v1(219.2,32) v1(219.2,30.99) v1(219.33,51.18) v1(219.96,51.69) v1(219.96,50.67) v1(220.35,41.78) v1(220.35,40.89) v1(220.98,41.27) v1(221.49,41.78) v1(221.49,40.89) v1(226.06,49.53) v1(226.06,3.81) v1(227.33,3.81) v1(232.41,20.32) v1(232.41,19.05) v1(232.41,3.81) v1(232.41,2.54) v1(233.68,20.32) v1(233.68,3.81) v1(233.68,2.54) v1(234.95,20.32) v1(234.95,2.54) v1(236.22,20.32) v1(236.22,2.54) v1(237.49,22.86) v1(237.49,21.59) v1(237.49,20.32) v1(237.49,2.54) v1(238.76,22.86) v1(238.76,21.59) v1(238.76,20.32) v1(238.76,19.05) v1(238.76,2.54) v1(239.4,46.35) v1(239.4,45.08) v1(239.4,43.81) v1(239.4,42.54) v1(239.4,41.27) v1(239.4,40) v1(239.4,38.1) v1(239.4,36.83) v1(239.4,35.56) v1(239.4,34.29) v1(239.4,33.02) v1(239.4,31.75) v1(239.4,30.48) v1(239.4,29.21) v1(239.4,27.94) v1(239.4,26.67) v1(239.4,25.4) v1(239.4,24.13) v1(240.03,2.54) v1(241.3,2.54) v1(242.57,2.54) v1(243.84,2.54) v1(245.11,2.54) v1(246.38,2.54) v1(247.65,2.54) v1(248.92,2.54) v1(250.19,2.54) v1(251.46,2.54) v1(252.73,2.54) v1(254,2.54) v1(255.27,2.54) v1(256.54,2.54) v1(257.81,2.54) v1(259.08,2.54) v1(260.35,2.54) v1(261.62,2.54) v1(262.89,2.54) v1(264.16,2.54) v1(265.43,2.54) v1(266.7,2.54) v1(267.97,2.54) v1(269.24,2.54) v1(270.51,2.54) v1(271.78,2.54) v1(273.05,2.54) v1(274.32,2.54) v1(275.59,2.54) v1(276.86,2.54) v1(278.13,2.54) v1(279.4,2.54) v1(280.67,2.54) v1(281.94,2.54) v1(283.21,2.54) v1(284.48,2.54) v1(285.75,2.54) v1(287.02,2.54) v1(288.29,2.54) v1(293.37,2.54) v1(293.37,1.27) v1(294.64,100.33) v1(294.64,99.06) v1(294.64,97.79) v1(295.28,2.54) v1(295.28,1.27) v1(297.18,90.81) v1(297.18,89.53) v1(297.18,88.26) v1(297.18,87) v1(297.18,85.72) v1(297.18,82.55) v1(297.18,81.28) v1(297.18,80.01) v1(297.18,78.74) v1(297.18,77.47) v1(297.18,74.29) v1(297.18,73.02) v1(297.18,71.75) v1(297.18,70.49) v1(297.18,69.21) v1(299.72,63.5) v1(299.72,62.23) v1(299.72,60.96) v1(299.72,59.69) v1(299.72,58.42) v1(302.26,34.29) v1(302.26,33.02) v1(302.26,31.75) v1(302.26,30.48) v1(302.26,29.21) v1(302.26,27.94) v1(302.26,26.67) v1(302.26,25.4) v1(302.26,24.13) v1(302.26,22.86) v1(302.26,21.59) v1(302.26,20.32) v1(302.26,19.05) v1(302.26,17.78) v1(302.26,16.51) v1(302.26,15.24) v1(302.26,13.97) v1(302.26,12.7) v1(302.26,11.43) v1(302.26,10.16) v1(302.26,8.89) v1(302.26,7.62) v1(302.9,99.69) v1(302.9,98.43) v1(302.9,97.15) v1(302.9,95.88) v1(302.9,94.62) v1(302.9,93.34) v1(302.9,92.07) v1(302.9,90.81) v1(302.9,89.53) v1(302.9,88.26) v1(302.9,87) v1(302.9,85.72) v1(302.9,84.45) v1(302.9,83.19) v1(302.9,81.91) v1(302.9,80.64) v1(302.9,79.38) v1(302.9,78.1) v1(302.9,76.83) v1(302.9,75.56) v1(302.9,74.29) v1(302.9,73.02) v1(302.9,71.75) v1(302.9,70.49) v1(302.9,69.21) v1(302.9,67.94) v1(302.9,66.04) v1(302.9,64.77) v1(302.9,63.5) v1(302.9,62.23) v1(302.9,60.96) v1(302.9,59.69) v1(302.9,58.42) v1(302.9,57.15) v1(303.53,34.29) v1(304.17,67.31) v1(304.17,66.04) v1(304.17,64.77) v1(304.17,63.5) v1(304.17,62.23) v1(304.17,60.96) v1(304.17,59.69) v1(304.17,58.42) v1(304.17,57.15) v1(304.17,55.88) v1(304.8,34.29) v1(305.44,67.31) v1(305.44,66.04) v1(305.44,64.77) v1(305.44,63.5) v1(305.44,62.23) v1(305.44,60.96) v1(305.44,59.69) v1(305.44,58.42) v1(305.44,57.15) v1(305.44,55.88) v1(306.07,34.29) v1(306.71,67.31) v1(307.34,34.29) v1(307.98,67.31) v1(307.98,50.16) v1(308.61,34.29) v1(309.25,67.31) v1(309.25,50.16) v1(309.88,34.29) v1(310.51,67.31) v1(310.51,50.16) v1(311.15,34.29) v1(311.79,67.31) v1(311.79,50.16) v1(312.42,34.29) v1(313.06,67.31) v1(313.06,50.16) v1(313.69,34.29) v1(314.32,67.31) v1(314.32,50.16) v1(314.96,34.29) v1(315.6,67.31) v1(315.6,50.16) v1(316.23,34.29) v1(316.87,67.31) v1(316.87,50.16) v1(317.5,34.29) v1(318.13,67.31) v1(318.13,50.16) v1(318.77,34.29) v1(319.41,67.31) v1(320.04,50.16) v1(320.04,34.29) v1(320.68,67.31) v1(321.31,50.16) v1(321.31,34.29) v1(321.94,67.31) v1(322.58,50.16) v1(322.58,34.29) v1(323.22,67.31) v1(323.85,50.16) v1(323.85,34.29) v1(324.49,67.31) v1(325.12,50.16) v1(325.12,34.29) v1(325.75,67.31) v1(326.39,50.16) v1(326.39,34.29) v1(327.03,67.31) v1(327.66,50.16) v1(327.66,34.29) v1(328.93,67.31) v1(328.93,66.04) v1(328.93,64.77) v1(328.93,63.5) v1(328.93,62.23) v1(328.93,60.96) v1(328.93,59.69) v1(328.93,58.42) v1(328.93,57.15) v1(328.93,55.88) v1(328.93,54.61) v1(328.93,53.34) v1(328.93,52.07) v1(328.93,50.8) v1(328.93,49.53) v1(328.93,34.29)
GND_ISO: length 27.1
  TOP w0.203: U10.17 194.21,43.95 v1(193.8,43.54) ; C255.2 169.01,85.02 U16.B2 ; v1(186.82,71.63) 186.82,71.25 187.05,71.02 U22.52 ; U17.B2 169.01,80.06 C256.2 ; U22.54 186.32,70.22 v1(185.67,70.87) ; C248.1 186.4,83.83 186.36,83.79 v1(186.31,83.79) ; T4.4 161.56,62.85 v1(161.54,62.87) ; C257.2 168.88,75.11 U18.B2 ; C221.2 v1(180.21,50.27)
  TOP w0.254: U19.2 201.27,83.41 202.1,82.59 C268.1 ; 193.83,48.33 194.08,48.08 U10.9 ; P11.5 183.1,95.22 v1(182.75,94.87)
  TOP w0.508: Y2.4 182.29,68.88 v1(182.58,69.16)
  BOTTOM w0.508: 197.9,46.61 197.9,45.63
  vias: v1(162.43,70.74) v1(162.43,69.47) v1(162.43,67.94) v1(162.43,66.42) v1(163.4,94.06) v1(163.75,88.62) v1(163.75,87.4) v1(163.75,86.08) v1(163.75,84.91) v1(163.83,62.99) v1(163.96,100.46) v1(163.96,70.74) v1(163.96,69.47) v1(163.96,67.94) v1(163.96,66.42) v1(164.31,78.36) v1(164.36,89.84) v1(164.47,93.09) v1(166.5,84.96) v1(167.26,78.77) v1(167.41,83.74) v1(167.41,73.74) v1(168.53,83.74) v1(168.53,78.77) v1(168.58,73.79) v1(171.73,83.9) v1(171.83,44.83) v1(171.93,78.87) v1(172.21,47.24) v1(172.34,50.11) v1(172.59,75.06) v1(172.59,73.84) v1(173.41,46.15) v1(174.27,51.69) v1(175.95,50.11) v1(178.56,100.08) v1(178.56,98.3) v1(178.56,96.9) v1(178.94,74.29) v1(178.99,67.08) v1(179.1,72.42) v1(179.1,70.84) v1(179.15,93.09) v1(179.71,84.2) v1(180.31,86.94) v1(180.26,66.98) v1(181.03,50.47) v1(181.86,81.66) v1(181.86,81.03) v1(181.86,80.26) v1(182.25,90.68) v1(182.25,47.75) v1(182.37,57.4) v1(182.5,81.66) v1(182.5,81.03) v1(182.5,80.26) v1(182.5,65.96) v1(182.91,46.25) v1(183.01,84.4) v1(183.26,94.36) v1(183.26,93.47) v1(183.26,92.58) v1(183.82,50.22) v1(184.28,77.09) v1(185.34,77.14) v1(185.67,94.36) v1(185.67,93.47) v1(185.67,92.58) v1(186.56,50.29) v1(187.33,77.8) v1(187.33,50.83) v1(187.33,49.4) v1(187.38,46.35) v1(187.38,44.53) v1(187.38,42.95) v1(188.47,87.25) v1(188.6,77.8) v1(188.6,60.32) v1(188.85,95.12) v1(188.85,93.85) v1(189.23,70.49) v1(189.23,69.85) v1(189.23,69.21) v1(189.23,68.58) v1(189.23,67.94) v1(189.23,67.31) v1(189.23,66.68) v1(189.23,66.04) v1(189.23,65.4) v1(190.5,70.49) v1(190.5,69.85) v1(190.5,69.21) v1(190.5,68.58) v1(190.5,67.94) v1(190.5,67.31) v1(190.5,66.68) v1(190.5,66.04) v1(190.5,65.4) v1(190.75,59.56) v1(191.77,99.69) v1(191.77,70.49) v1(191.77,69.85) v1(191.77,69.21) v1(191.77,68.58) v1(191.77,67.94) v1(191.77,67.31) v1(191.77,66.68) v1(191.77,66.04) v1(191.77,65.4) v1(192.84,90.86) v1(192.84,89.99) v1(193.04,98.43) v1(193.04,70.49) v1(193.04,69.85) v1(193.04,69.21) v1(193.04,68.58) v1(193.04,67.94) v1(193.04,67.31) v1(193.04,66.68) v1(193.04,66.04) v1(193.04,65.4) v1(193.83,39.34) v1(193.93,53.59) v1(194.06,48.26) v1(194.31,70.49) v1(194.31,69.85) v1(194.31,69.21) v1(194.31,68.58) v1(194.31,67.94) v1(194.31,67.31) v1(194.31,66.68) v1(194.31,66.04) v1(194.31,65.4) v1(194.95,99.69) v1(195.86,85.47) v1(196.09,82.68) v1(196.22,98.43) v1(196.27,85.06) v1(196.37,83.19) v1(196.6,47.09) v1(196.6,46.46) v1(196.6,45.82) v1(197.23,47.09) v1(197.23,46.46) v1(197.23,45.82) v1(197.87,47.09) v1(197.87,46.46) v1(197.87,45.82) v1(198.12,99.69) v1(199.01,94.87) v1(199.01,93.09) v1(199.01,84.96) v1(199.39,98.43) v1(199.36,38.28) v1(200.74,88.26) v1(200.74,87.5) v1(200.89,38.28) v1(201.3,99.69) v1(201.3,82.17) v1(201.5,87.5) v1(201.55,94.87) v1(201.55,93.09) v1(201.55,88.26) v1(202.26,88.32) v1(202.26,87.45) v1(202.41,38.28) v1(202.57,98.43) v1(203.48,39.29) v1(204.47,99.69) v1(204.85,81.79) v1(205,51.03) v1(205,50.22) v1(210.82,48.13) v1(212.22,47.5) v1(213.23,57.66) v1(213.23,55.24) v1(213.23,52.83) v1(213.23,51.43) v1(213.23,50.04) v1(213.23,48.77) v1(213.26,60.05) v1(213.59,100.46) v1(213.61,99.31) v1(213.61,98.17) v1(213.61,96.9) v1(213.59,95.76) v1(213.61,94.62) v1(213.61,93.47) v1(213.61,92.2) v1(213.59,90.81) v1(213.61,89.66) v1(213.61,88.52) v1(213.61,87.25) v1(213.59,85.85) v1(213.61,84.71) v1(213.61,83.57) v1(213.61,82.3) v1(213.61,81.03) v1(213.61,79.88) v1(213.61,74.04)
VBATTP: length 23.5
  TOP w0.203: C214.1 161.26,43.56 161.23,43.53 160.94,43.53 v1(160.78,43.69)
  TOP w0.254: R187.1 133.59,5.03 U6.3
  TOP w0.508: R1.2 80.26,93.76 D22.C ; R1.2 v1(81.95,90.26) ; R1.2 R337.2 75.65,90.26 74.68,89.28 P1.1
  TOP w0.635: C214.1 165.12,43.56 U9.5 U9.1 ; T4.3 162.61,48.83 D17.A
  vias: v1(34.95,30.76) v1(34.95,29.95) v1(34.95,29.24) v1(35.61,30.71) v1(35.61,29.95) v1(35.61,29.24) v1(49.25,43.56) v1(49.25,42.85) v1(49.86,43.56) v1(49.86,42.85) v1(74.3,94.87) v1(74.3,94.23) v1(74.3,93.6) v1(74.3,92.96) v1(74.93,94.87) v1(74.93,94.23) v1(74.93,93.6) v1(74.93,92.96) v1(75.56,94.87) v1(75.56,94.23) v1(75.56,93.6) v1(75.56,92.96) v1(76.2,94.87) v1(76.2,94.23) v1(76.2,93.6) v1(76.2,92.96) v1(76.83,94.87) v1(76.83,94.23) v1(76.83,93.6) v1(76.83,92.96) v1(77.47,94.87) v1(77.47,94.23) v1(77.47,93.6) v1(77.47,92.96) v1(78.11,94.87) v1(78.11,94.23) v1(78.11,93.6) v1(78.11,92.96) v1(81.25,94.74) v1(81.25,94.11) v1(81.25,93.47) v1(81.25,92.84) v1(81.28,92.2) v1(81.28,91.57) v1(81.28,90.93) v1(81.28,90.3) v1(81.92,94.74) v1(81.92,94.11) v1(81.92,93.47) v1(81.92,92.84) v1(81.92,92.2) v1(81.92,91.57) v1(81.92,90.93) v1(114.3,3.81) v1(114.3,2.54) v1(115.57,3.81) v1(115.57,2.54) v1(116.84,3.81) v1(116.84,2.54) v1(118.11,3.81) v1(118.11,2.54) v1(119.38,3.81) v1(119.38,2.54) v1(120.65,3.81) v1(120.65,2.54) v1(121.92,3.81) v1(121.92,2.54) v1(123.19,6.35) v1(123.19,5.08) v1(123.19,3.81) v1(123.19,2.54) v1(124.46,6.35) v1(124.46,5.08) v1(124.46,3.81) v1(124.46,2.54) v1(128.27,6.22) v1(128.27,4.95) v1(128.27,3.81) v1(128.27,2.54) v1(129.16,6.22) v1(129.16,4.95) v1(129.16,3.81) v1(129.16,2.54) v1(130.94,3.81) v1(130.94,2.54) v1(132.21,3.81) v1(132.21,2.54) v1(133.48,3.81) v1(133.48,2.54) v1(160.81,50.27) v1(160.81,49.56) v1(160.81,48.79) v1(160.78,46.61) v1(160.78,45.85) v1(160.78,45.21) v1(160.78,44.45) v1(161.42,50.27) v1(161.42,49.56) v1(161.47,48.79)
VBUS: length 8.5
  TOP w0.254: v1(186.36,84.66) 186.11,84.91 U14.5
  TOP w0.508: U21.5 187.57,90.68 C290.2 189.05,90.67 188.21,91.5 v1(188.21,91.69) v1(188.21,92.33) ; R229.2 186.66,87 v1(187.12,87.45)
  L4_POWER w0.508: v1(188.21,92.33) 188.24,92.31 v1(188.85,92.31) v1(189.48,92.31)
  vias: v1(188.85,91.69) v1(189.48,91.69)
VDD: length 13.8
  TOP w0.203: C248.2 v1(187.27,86.54)
  TOP w0.254: U14.4 v1(185.46,83.79) ; U14.6 185.48,85.43 C248.2
  TOP w0.762: D19.C 167.44,67.49 C215.1 167.37,71.61 D20.C TP8.1
  vias: v1(169.39,70.23) v1(169.42,69.62) v1(170.28,70.23) v1(170.28,69.6)
VDDIO: length 21.1
  TOP w0.203: 197.94,65.91 197.79,65.91 197.49,66.22 U22.22 ; U22.63 186.2,66.62 v1(185.62,66.04) ; v1(194.44,60.58) 193.84,60.58 192.82,61.59 U22.11
  TOP w0.508: 197.94,65.91 v1(198.5,65.91) ; P12.1 176.91,98.93 177.42,98.43 v1(177.42,93.22)
  BOTTOM w0.508: v1(198.5,65.91) 198.25,66.17 C281.2 ; v1(185.62,66.04) 185.62,66.19 186.36,66.93 C283.2
VDDIOH: length 9.7
  TOP w0.203: v1(185.62,64.85) 185.88,64.85 186.85,65.82 U22.65 ; v1(193.74,61.66) 193.22,62.17 U22.12 ; 196.88,64.29 196.88,64.69 196.55,65.02 U22.19
  TOP w0.508: v1(197.4,63.72) 197.4,63.77 196.88,64.29
  BOTTOM w0.508: C284.2 186.18,65.4 v1(185.62,64.85) ; C282.2 v1(197.4,63.72)
0P9: length 64.2
  TOP w0.203: v1(192.15,55.37) 192.41,55.63 R350.1
  L3_SIGNAL w0.203: v1(192.15,55.37) 191.26,54.48 179.71,54.48 P14.11
  BOTTOM w0.254: v1(192.15,55.37) 197.15,60.38 208.05,60.38 209.88,62.2 209.88,82.73 210.34,83.19 P20.2
0P10: length 32.5
  TOP w0.203: U10.8 195.48,48.82 195.28,49.02 v1(193.68,49.02) ; v1(193.68,55.37) 193.68,55.5 193.93,55.75 R351.1
  L3_SIGNAL w0.203: v1(193.68,49.02) 194.69,49.02 195.33,49.66 195.33,53.09 193.68,54.74 v1(193.68,55.37) 193.17,55.37 191.77,53.97 177.67,53.97 P14.12
0P23: length 34.5
  TOP w0.203: v1(200.15,49.15) 200.15,48.41 199.82,48.08 U10.32 ; v1(195.45,55.5) R352.1
  L3_SIGNAL w0.203: P13.1 207.77,59.03 205.11,56.36 203.84,56.36 203.1,55.63 195.58,55.63 v1(195.45,55.5)
  L6_SIGNAL w0.203: v1(195.45,55.5) 196.09,56.13 200.28,56.13 201.8,54.61 201.8,50.29 200.66,49.15 v1(200.15,49.15)
1P7: length 13.6
  TOP w0.203: v1(202.44,56.39) 201.59,56.39 R353.1
  L3_SIGNAL w0.203: P13.2 206.76,66.29 206.12,65.66 206.12,62.74 202.44,59.06 v1(202.44,56.39)
1P8: length 10.2
  TOP w0.203: 207.77,68.83 206.38,67.44 206.38,62.65 R354.1
1P9: length 26.9
  TOP w0.203: v1(198.5,54.99) R355.1
  L3_SIGNAL w0.203: v1(198.5,54.99) 198.55,55.04 205.51,55.04 209.22,58.75 209.22,69.93 P13.4
1P10: length 46
  TOP w0.203: v1(200.03,54.48) R356.1
  TOP w0.254: v1(199.64,49.78) 198.98,49.12 U10.1 ; R398.1 192.02,50.67 192.28,50.42 v1(192.91,50.42)
  L3_SIGNAL w0.203: P13.5 208.03,73.91 209.68,72.26 209.68,58.42 205.74,54.48 v1(200.03,54.48)
  L6_SIGNAL w0.203: v1(200.03,54.48) 201.09,53.42 201.09,50.32 200.56,49.78 v1(199.64,49.78) 199.39,49.53 194.06,49.53 193.17,50.42 v1(192.91,50.42)
1P11: length 16.6
  TOP w0.203: R357.1 204.47,61.72 205.82,63.07 205.82,74.5 207.77,76.45
1P12: length 17.9
  TOP w0.203: v1(204.85,63.25) R358.1
  BOTTOM w0.203: v1(204.85,63.25) 204.85,63.42 206.48,65.05 206.48,77.7 P13.7
1P15: length 18.9
  TOP w0.203: R359.1 v1(204.85,64.77)
  BOTTOM w0.203: P13.8 205.97,79.73 205.97,65.89 v1(204.85,64.77)
1P16: length 19.9
  TOP w0.203: v1(204.85,66.29) R360.1
  BOTTOM w0.203: v1(204.85,66.29) 205.51,66.95 205.51,81.81 207.77,84.07
1P18: length 19.9
  TOP w0.203: R361.1 v1(204.72,69.34)
  BOTTOM w0.203: P13.10 207.77,85.9 204.09,82.22 204.09,69.98 v1(204.72,69.34)
1P19: length 24.9
  TOP w0.203: R362.1 v1(204.85,67.82)
  BOTTOM w0.203: v1(204.85,67.82) 204.22,67.82 203.58,68.45 203.58,82.32 205.84,84.58 205.84,87.22 207.77,89.15
1P20: length 38.2
  TOP w0.203: v1(204.72,73.91) R363.1
  L3_SIGNAL w0.203: P14.1 176.86,82.73 193.22,82.73 194.44,81.51 194.44,77.09 197.61,73.91 v1(204.72,73.91)
1P21: length 44.6
  TOP w0.203: R364.1 v1(204.72,75.44)
  L3_SIGNAL w0.203: 174.5,82.55 173.58,82.55 173.05,83.08 173.05,86.28 173.36,86.59 175.08,86.59 178.54,83.13 193.6,83.13 194.95,81.79 194.95,77.47 196.98,75.44 v1(204.72,75.44)
2P7: length 29.2
  TOP w0.203: R365.1 183.22,56.39 v1(181.99,56.39)
  L6_SIGNAL w0.203: v1(181.99,56.39) 181.61,56.77 181.61,66.7 180.06,68.25 180.06,76.43 176.48,80.01 P14.3
2P8: length 30.8
  TOP w0.203: R366.1 184.79,55.88 v1(184.28,55.37)
  L6_SIGNAL w0.203: P14.4 178.16,77.47 179.65,75.97 179.65,57.84 182.12,55.37 v1(184.28,55.37)
2P24: length 10.3
  TOP w0.203: R369.1 v1(176.66,63.25)
  L6_SIGNAL w0.203: v1(176.66,63.25) 176.66,67.69 P14.7
2P25: length 22.8
  TOP w0.203: R370.1 v1(190.88,55.37)
  L3_SIGNAL w0.203: v1(190.88,55.37) 190.88,56.06 181.03,65.91 175.9,65.91 174.5,67.31
3P4: length 32.5
  TOP w0.203: R371.1 v1(193.78,77.8)
  L3_SIGNAL w0.203: v1(176.1,76.73) 176.5,77.14 179.25,77.14 180.31,76.07 188.34,76.07 190.07,77.8 v1(193.78,77.8)
  BOTTOM w0.203: v1(176.1,76.73) 176.15,76.68 176.15,66.42 P14.9
4P0: length 6.1
  TOP w0.254: R372.1 177.17,64.9 P14.10
ADBMS6822_IM1: length 22.5
  TOP w0.203: v1(192.15,48.26) 193.04,48.26 193.72,47.58 U10.10
  TOP w0.254: v1(177.37,53.31) R208.2 177.35,51.99 C222.1
  L3_SIGNAL w0.254: v1(177.37,53.31) 182.55,53.31 187.58,48.29 192.13,48.29 v1(192.15,48.26)
ADBMS6822_IM2: length 19.1
  TOP w0.203: U10.18 195.98,43.56 195.33,42.9 v1(194.69,42.9)
  TOP w0.254: C223.1 183.84,52.08 R209.2 185.91,51.28 v1(186.21,51.28)
  L3_SIGNAL w0.254: v1(194.69,42.9) 194.69,46.74 189.89,51.54 186.97,51.54 186.72,51.28 v1(186.21,51.28)
ADBMS6822_IP1: length 27.7
  TOP w0.203: U10.11 193.46,47.08 193.07,47.47 192.56,47.47 v1(192.53,47.5)
  TOP w0.254: v1(173.3,51.99) 172.38,51.99 C220.1 172.36,52.01 R204.2
  L3_SIGNAL w0.254: v1(173.3,51.99) 174.02,52.7 182.45,52.7 185.85,49.3 185.85,47.98 186.87,46.96 192.15,46.96 192.53,47.35 v1(192.53,47.5)
ADBMS6822_IP2: length 25.3
  TOP w0.203: U10.19 196.48,43.29 195.33,42.14 v1(194.69,42.14)
  TOP w0.254: v1(181.03,52.04) C221.1 180.21,52.03 R205.2
  L3_SIGNAL w0.254: v1(194.69,42.14) 186.66,42.14 185.72,43.08 185.72,46.74 181.03,51.44 v1(181.03,52.04)
BATT1_CELL1: length 109.5
  TOP w0.381: v1(24.89,50.42) 25.65,49.66 R40.1
  TOP w1.016: P1.17 18.6,89.15 C31.2 14.09,84.64 C32.1 3.3,73.97 3.3,33.53 8.76,28.07 v1(10.54,28.07) R55.1 R56.1
  L6_SIGNAL w0.381: v1(10.54,28.07) 11.68,29.21 11.68,39.37 22.73,50.42 v1(24.89,50.42)
BATT1_CELL2: length 108.1
  TOP w0.381: v1(23.11,54.48) 24.93,54.48 R38.1 27.09,52.32 28.11,52.32 R39.1
  TOP w1.016: P1.16 20.07,87.05 18.75,87.05 C31.1 15.91,84.21 C30.2 4.9,73.29 4.9,38.68 6.63,36.96 v1(9.91,36.96) R53.1 R54.1
  L6_SIGNAL w0.381: v1(23.11,54.48) 13.08,54.48 9.68,51.08 9.68,37.19 v1(9.91,36.96)
BATT1_CELL3: length 85.1
  TOP w0.381: R37.1 v1(25.95,55.54)
  TOP w1.016: R52.1 R51.1 v1(10.79,45.97) 8.76,45.97 6.35,48.39 6.35,72.52 15.53,81.69 C29.2 15.57,81.7 C30.1 19.14,85.27 21.79,85.27 P1.15
  L6_SIGNAL w0.381: v1(25.95,55.54) 25.62,55.54 22.68,52.6 13.54,52.6 10.79,49.86 v1(10.79,45.97)
BATT1_CELL4: length 83.1
  TOP w0.381: R36.1 v1(29.25,59.18) 29.25,64.56 29.81,65.11 R35.1
  TOP w1.016: P1.14 23.49,83.47 C28.2 19.59,83.47 16.69,80.57 C29.1 16.61,80.57 16.43,80.39 11.65,75.61 11.65,75.53 7.87,71.75 7.87,56.01 8.89,54.99 v1(10.67,54.99) R49.1 R50.1
  L6_SIGNAL w0.381: v1(29.25,59.18) 28.87,58.8 14.48,58.8 v1(10.67,54.99)
BATT1_CELL5: length 65.9
  TOP w0.381: R47.1 13.21,64.05 v1(13.21,67.06) ; R34.1 32.68,65.11 v1(32.26,65.53)
  TOP w1.016: P1.13 32.68,89.05 C27.2 25.49,81.87 C28.1 20.15,81.87 17.32,79.05 17.24,79.05 17.07,78.87 13.17,74.98 R47.1 R48.1
  L3_SIGNAL w0.381: v1(13.21,67.06) 30.23,67.06 31.75,65.53 v1(32.26,65.53)
BATT1_CELL6: length 52.7
  TOP w0.381: v1(37.97,66.8) R32.1 36.96,64.35 36.96,62.83 36.58,62.45 36.58,62.44 R33.1 ; v1(22.61,76.99) 22.61,76.72
  TOP w1.016: R46.1 R45.1 22.61,75.1 22.61,76.72 C27.1 27.24,81.37 28.74,82.88 C26.2 30.77,84.96 35.16,84.96 36.18,85.98 P1.12
  L6_SIGNAL w0.381: v1(37.97,66.8) 37.49,67.28 32.08,67.28 22.61,76.76 v1(22.61,76.99)
BATT1_CELL7: length 46.2
  TOP w0.381: v1(31.37,77.09) 31.75,76.71 31.75,76.58 ; R31.1 v1(40.17,65.37)
  TOP w1.016: P1.11 39.43,88.91 C25.2 38.08,81.82 C26.1 29.08,81.01 29.08,79.25 31.75,76.58 R43.1 R44.1
  L6_SIGNAL w0.381: v1(40.17,65.37) 40.17,68.29 v1(31.37,77.09)
BATT1_CELL8: length 44.1
  TOP w0.381: R29.1 40.51,74.97 v1(40.51,77.47) ; R30.1 43.96,62.19 44.34,62.57 44.34,63.86 44.83,64.35 R13.1 v1(47.03,64.35)
  TOP w1.016: P1.10 43.18,84.67 C8.2 41.97,83.45 C25.1 40.64,81.97 R29.1 R42.1
  L6_SIGNAL w0.381: v1(40.51,77.47) 47.03,70.95 v1(47.03,64.35)
BATT1_CELL9: length 37.1
  TOP w0.254: R12.1 v1(48.09,64.35)
  TOP w0.381: v1(45.09,76.96) 45.09,76.83
  TOP w1.016: P1.9 46.7,89.13 C7.2 46.7,85.93 C8.1 43.11,78.81 45.09,76.83 R28.1 R27.1
  L6_SIGNAL w0.381: v1(48.09,64.35) 49.15,65.4 49.15,72.9 v1(45.09,76.96)
BATT1_CELL10: length 47.8
  TOP w0.381: v1(56.01,61.85) R10.1 55.03,60.67 54.52,61.17 R11.1 ; v1(53.98,77.09) 53.98,76.96
  TOP w1.016: R25.1 R26.1 53.98,76.96 55.12,78.1 55.12,81.13 54.07,82.17 50.42,82.17 48.3,84.29 C7.1 48.3,87.28 P1.8
  L6_SIGNAL w0.381: v1(56.01,61.85) 56.01,75.06 v1(53.98,77.09)
BATT1_CELL11: length 44.5
  TOP w0.381: v1(61.09,57.02) 61.09,55.67 R9.1
  TOP w1.016: P1.7 53.68,84.83 C6.1 57.71,80.8 57.77,80.8 v1(61.35,77.22) 62.99,75.57 R24.1 R23.1
  L6_SIGNAL w0.381: v1(61.35,77.22) 61.35,57.28 v1(61.09,57.02)
BATT1_CELL12: length 70.8
  TOP w0.381: v1(72.9,67.82) 72.9,65.32 R22.1 ; v1(59.4,51.09) R7.1 59.4,52.32 R8.1
  TOP w1.016: P1.6 57.18,83.65 C5.1 58.9,81.94 61.3,79.54 C4.2 68.42,79.54 72.94,75.02 R22.1 R21.1
  L3_SIGNAL w0.381: v1(59.4,51.09) 64.81,51.09 73.15,59.44 73.15,67.56 v1(72.9,67.82)
BATT1_CELL13: length 71.2
  TOP w0.381: R6.1 v1(61.05,45.89) ; v1(74.93,56.9) 74.42,56.39
  TOP w1.016: R19.1 R20.1 74.46,56.39 75.82,57.75 75.82,74.86 69.56,81.11 C3.2 65.33,81.11 C4.1 63.01,81.14 60.68,83.47 P1.5
  L3_SIGNAL w0.381: v1(61.05,45.89) 66.84,45.89 74.93,53.97 v1(74.93,56.9)
BATT1_CELL14: length 78.6
  TOP w0.381: R5.1 58.89,45.72 R4.1 59.44,44.96 v1(60.07,45.59)
  TOP w1.016: R17.1 R18.1 v1(75.56,47.24) 77.6,49.28 77.6,75.23 C2.2 70.12,82.72 C3.1 65.49,82.72 64.18,84.03 P1.4
  L3_SIGNAL w0.381: v1(75.56,47.24) 73.28,44.96 60.7,44.96 v1(60.07,45.59)
BATT1_CELL15: length 99.2
  TOP w0.254: R3.1 57.36,39 v1(57.35,38.99)
  TOP w0.889: D21.A v1(78.37,83.58)
  TOP w1.016: R15.1 R16.1 v1(75.18,38.23) 76.45,38.23 79.38,41.15 79.38,75.69 73.07,82 C1.2 73.06,82.01 71.73,83.33 C2.1 67.69,87.4 67.69,89.14 P1.3
  L3_SIGNAL w0.381: v1(75.18,38.23) 74.93,38.48 57.78,38.48 57.35,38.91 v1(57.35,38.99)
  BOTTOM w0.889: v1(78.37,83.58) 73.25,83.58 P1.3
BATT1_CELL16: length 108
  TOP w0.381: R14.1 72.94,27.85 71.75,26.67 66.8,26.67 64.74,28.73 64.74,36.09 62.61,38.23 55.63,38.23 54.06,39.79 R2.1
  TOP w0.508: P1.2 73.21,87.12 76.33,87.12 77.76,88.56 R337.1
  TOP w1.016: P1.2 71.18,86.18 74.19,83.16 74.19,83.13 74.22,83.13 81.31,76.05 81.31,35.93 74.46,29.08 R14.1
BATT2_CELL1: length 108.7
  TOP w0.381: v1(104.56,50.42) 105.32,49.66 R125.1 ; v1(90.55,29.08) 90.68,29.08 91.69,28.07 91.82,28.07
  TOP w1.016: P4.17 98.1,89.15 C125.2 93.74,84.79 C126.1 85.17,76.07 85.17,34.72 91.82,28.07 R140.1 R141.1
  L6_SIGNAL w0.381: v1(90.55,29.08) 90.55,42.63 98.34,50.42 v1(104.56,50.42)
BATT2_CELL2: length 103.5
  TOP w0.381: v1(102.78,54.48) 104.6,54.48 R123.1 106.63,52.45 107.65,52.45 R124.1
  TOP w1.016: R139.1 R138.1 v1(89.58,36.96) 87.76,36.96 86.74,37.97 86.74,75.44 95.56,84.26 C124.2 95.57,84.37 C125.1 97.95,86.74 99.43,86.74 P4.16
  L6_SIGNAL w0.381: v1(102.78,54.48) 97.03,54.48 88.9,46.35 88.9,37.63 v1(89.58,36.96)
BATT2_CELL3: length 82.8
  TOP w0.381: R122.1 v1(105.62,55.54)
  TOP w1.016: 96.72,83.13 C124.1 95.28,81.71 C123.2 95.28,81.69 ; 96.72,83.13 95.28,81.69 ; 96.72,83.13 98.55,84.96 101.16,84.96 P4.15 ; 95.28,81.69 88.11,74.52 88.11,46.99 89.13,45.97 v1(90.47,45.97) R136.1 R137.1
  L6_SIGNAL w0.381: v1(105.62,55.54) 105.27,55.54 101.63,51.89 96.38,51.89 v1(90.47,45.97)
BATT2_CELL4: length 80.5
  TOP w0.381: R121.1 v1(108.92,59.18) 108.92,64.56 109.48,65.11 R120.1
  TOP w1.016: R135.1 R134.1 v1(90.34,54.99) 89.53,55.79 89.53,73.69 C123.1 96.45,80.57 99.35,83.47 C122.2 101.54,83.44 103.13,83.44 P4.14
  L6_SIGNAL w0.381: v1(108.92,59.18) 102.49,59.18 100.08,56.77 92.12,56.77 v1(90.34,54.99)
BATT2_CELL5: length 62.9
  TOP w0.381: v1(111.93,65.53) 112.35,65.11 R119.1
  TOP w1.016: P4.13 112.35,88.97 C121.2 105.25,81.87 C122.1 99.96,81.87 92.88,74.79 v1(92.88,67.06) 92.88,64.05 R132.1 R133.1
  L3_SIGNAL w0.381: v1(111.93,65.53) 110.28,67.18 93.01,67.18 v1(92.88,67.06)
BATT2_CELL6: length 49.3
  TOP w0.381: v1(116.84,66.8) 117.64,66 R117.1 116.63,64.35 116.63,62.83 116.25,62.45 116.25,62.44 R118.1
  TOP w1.016: R131.1 R130.1 103.05,75.27 v1(103.05,76.83) 103.05,77.41 C121.1 106.99,81.37 108.5,82.88 C120.2 112.56,87 113.69,87 P4.12
  L6_SIGNAL w0.381: v1(116.84,66.8) 116.51,67.13 111.98,67.13 103.05,76.06 v1(103.05,76.83)
BATT2_CELL7: length 45
  TOP w0.381: R116.1 v1(119.84,65.37)
  TOP w1.016: P4.11 119.19,88.99 C119.2 118.44,82.42 110.25,82.42 C120.1 109.65,78.57 v1(111,77.22) 111.51,76.71 R128.1 R129.1
  L6_SIGNAL w0.381: v1(111,77.22) 119.84,68.37 v1(119.84,65.37)
BATT2_CELL8: length 41.3
  TOP w0.381: v1(126.7,64.35) R98.1 124.5,64.35 124.01,63.86 124.01,62.57 123.63,62.19 R115.1
  TOP w1.016: R127.1 R114.1 120.32,74.92 v1(120.32,77.27) C119.1 121.73,83.45 C102.2 121.73,88.03 P4.10
  L6_SIGNAL w0.381: v1(126.7,64.35) 126.92,64.57 126.92,70.28 120.32,76.88 v1(120.32,77.27)
BATT2_CELL9: length 38.6
  TOP w0.254: R97.1 v1(127.76,64.35)
  TOP w1.016: R112.1 R113.1 124.76,74.93 v1(124.76,76.96) 124.76,78.57 122.86,80.47 C102.1 126.45,85.93 C101.2 126.45,89.05 P4.9
  L6_SIGNAL w0.381: v1(127.76,64.35) 129.92,66.51 129.92,72.9 125.86,76.96 v1(124.76,76.96)
